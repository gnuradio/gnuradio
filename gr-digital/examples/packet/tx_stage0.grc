options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: tx_stage0
    output_language: python
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '2000'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '150'
    minsize: '15'
  states: {}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: tap0
    istunflag: 'False'
    mtu: '10000'
  states: {state: disabled}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_random_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [network_tuntap_pdu_0, pdus, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
