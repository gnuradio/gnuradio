options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: formatter_ofdm
    output_language: python
  states: {}

blocks:
- name: frame_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, len_key, frame_key, num_key, header_mod.bits_per_symbol(), payload_mod.bits_per_symbol(), scramble)
  states: {}
- name: hdr_format_bb
  id: variable
  parameters:
    comment: |-
      Need another for this path
      as the formatters keep state.
    value: digital.header_format_ofdm(occupied_carriers, 1, len_key, frame_key, num_key, header_mod.bits_per_symbol(), payload_mod.bits_per_symbol(), scramble)
  states: {}
- name: header_mod
  id: variable_constellation_rect
  parameters:
    const_points: '[1, -1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: payload_mod
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: scramble
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '2000'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '50'
    minsize: '50'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: len_key
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format_bb
    len_tag_key: len_key
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_parser_b_0_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format_bb
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_1, in]
- [blocks_repack_bits_bb_0, '0', digital_protocol_parser_b_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_tag_debug_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_protocol_parser_b_0_0, '0']
- [digital_crc32_async_bb_1, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digital_crc32_async_bb_1, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, blocks_message_debug_0, print_pdu]
- [digital_protocol_formatter_async_0, header, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_protocol_parser_b_0, info, blocks_message_debug_0_0, print]
- [digital_protocol_parser_b_0_0, info, blocks_message_debug_0_0_0, print]

metadata:
  file_format: 1
