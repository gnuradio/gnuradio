options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 16*10
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[1,1,1,1,1,1,1,1,-1,-1,-1,-1,-1,-1,-1,-1]'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: '20'
    pre_padding: '0'
    type: complex
    window: firdes.window(fft.window.WIN_HANN, 50, 0)
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: packet_len
    post_padding: '20'
    pre_padding: '0'
    type: complex
    window: firdes.window(fft.window.WIN_HANN, 50, 0)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 0,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    name: With Phasing Symbols
    size: '512'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    name: Without Phase Symbols
    size: '512'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_burst_shaper_xx_0_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_burst_shaper_xx_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
