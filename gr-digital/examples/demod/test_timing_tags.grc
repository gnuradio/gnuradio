<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_timing_tags</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, eb, 44*nfilts)</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/tmp/rx_mm_samples.32fc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/tmp/rx_pfb_samples.32fc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_1</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/tmp/rx_mm_samples.32f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_1_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>/tmp/rx_pfb_samples.32f</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_meta_source</key>
<param><key>id</key><value>blocks_file_meta_source_0</value></param>
<param><key>comment</key><value>Use generate_samples.grc
to create the input file</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>file</key><value>/tmp/generated_samples.32fc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*10</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.01</value></param>
<param><key>gain_omega</key><value>(0.01**2)/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0_0</value></param>
<param><key>gain_mu</key><value>0.01</value></param>
<param><key>gain_omega</key><value>(0.01**2)/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>3.14/100.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>3.14/100.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tabs@0:0,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>gui_hint</key><value>tabs@1:0,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_0</value></param>
<param><key>gui_hint</key><value>tabs@1:1,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.005</value></param>
<param><key>tr_level</key><value>0.2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>PFB</value></param>
<param><key>label1</key><value>M&amp;M</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_meta_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
