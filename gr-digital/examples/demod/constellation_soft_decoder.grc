options:
  parameters:
    author: Tom Rondeau
    description: Explore Soft Decoding of constellations. Selec the constellation from the available objects.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: constellation_soft_decoder
    output_language: python
    title: Soft Decoder Example
  states: {}

blocks:
- name: axis_limit
  id: variable
  parameters:
    value: '1.25'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: '1.0'
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: '1.0'
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: axis_limit
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: digital.soft_dec_table_generator(digital.sd_psk_2, 8, axis_limit)
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: axis_limit
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: digital.soft_dec_table_generator(digital.sd_psk_4, 8, axis_limit)
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: axis_limit
    const_points: digital.qam_16()[0]
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: digital.soft_dec_table_generator(digital.sd_qam_16, 8, axis_limit)
    sym_map: digital.qam_16()[1]
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    axis_limit: '1.0'
    const_points: digital.qam_16_1()[0]
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.qam_16_1()[1]
    type: calcdist
  states: {state: disabled}
- name: delay
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Delay
    label0: BPSK
    label1: QPSK
    label2: QAM16
    num_opts: '3'
    option0: '29'
    option1: '58'
    option2: '116'
    type: int
    value: '{1:29, 2:58, 4:116}[constel.bits_per_symbol()]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Channel: Noise Voltage'
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
    widget: eng_slider
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '200'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constel
    npwr: '-1'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_decode()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: note_auto
  id: note
  parameters:
    note: auto-build LUT
  states: {}
- name: note_py
  id: note
  parameters:
    note: Python-generated LUT
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: Soft
    label2: Hard
    label3: Orig
    name: ''
    nconnections: '3'
    size: '500'
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clock_sync
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: input_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clock_sync
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: input_bits
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0, '0', virtual_sink_1, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_delay_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_1, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
  grc_version: g8303f6db8
