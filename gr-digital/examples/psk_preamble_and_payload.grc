<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_preamble_and_payload</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>map(lambda x: (-x+1)/2, preamble)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gap</value></param>
<param><key>label</key><value>Burst gap</value></param>
<param><key>value</key><value>3000</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengths</key><value>len(preamble)/8,payload_len</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengths</key><value>(len(preamble)+8*payload_len)*sps, gap</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>payload_len</value></param>
<param><key>label</key><value>Payload Length</value></param>
<param><key>value</key><value>92</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>constel</value></param>
<param><key>label</key><value>Constellation Object</value></param>
<param><key>value</key><value>""</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>label</key><value>Preamble (in bits)</value></param>
<param><key>value</key><value>[0,]</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>label</key><value>Excess BW</value></param>
<param><key>value</key><value>0.35</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>constel</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>num_samps</key><value>100000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>[0, 255, 0, 255]</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>packets</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
