options:
  parameters:
    generate_options: qt_gui
    id: test_tcp_source_client
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1691e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: grnet_tcp_source_0
  id: grnet_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'False'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [grnet_tcp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
