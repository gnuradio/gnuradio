options:
  parameters:
    author: Robin Ekman
    generate_options: no_gui
    id: test_udp_source_multicast
    output_language: python
    title: Test UDP Source Multicast
  states: {}

blocks:
- name: address
  id: parameter
  parameters:
    label: Host address
    type: str
    value: 239.0.0.10
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.bin
    type: byte
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: address
    mtu: '10000'
    port: port
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '1024'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: port
  id: parameter
  parameters:
    label: Port
    type: str
    value: '50500'
  states: {}

connections:
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0_0, pdus]
- [pdu_pdu_to_stream_x_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: gc01a82d
