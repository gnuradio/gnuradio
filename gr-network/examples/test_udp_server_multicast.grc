options:
  parameters:
    author: Robin Ekman
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: test_udp_source_multicast
    output_language: python
    title: UDP Multicast Demo (PDU)
  states: {}

blocks:
- name: packet_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: address
  id: parameter
  parameters:
    label: Host address
    type: str
    value: 239.0.0.10
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self):
              gr.decim_block.__init__(
                  self,
                  name='Reinterpret Cast',
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
                  decim=8
              )

          def work(self, input_items, output_items):
              n = len(input_items[0]) // 8
              output_items[0][:] = input_items[0][0:8*n].view(np.complex64)
              return len(output_items[0])
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: address
    mtu: '10000'
    port: port
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: address
    mtu: '10000'
    port: port
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '1024'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: port
  id: parameter
  parameters:
    label: Port
    type: str
    value: '50500'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0_0, pdus]
- [pdu_pdu_to_stream_x_0_0, '0', epy_block_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_1, pdus]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-945-g959da132
