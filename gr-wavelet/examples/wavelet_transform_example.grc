options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: wavelet_transform_example
    output_language: python
    title: Wavelet Transform and Power Spectrum Example
  states: {}

blocks:
- name: order
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Original vs Reconstructed"'
    nconnections: '2'
    size: vec_len
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Wavelet Power Spectrum"'
    vlen: (vec_len - 1).bit_length()
    x_axis_label: '"Scale Level"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Power"'
  states: {}
- name: wavelet_wavelet_ff_0
  id: wavelet_wavelet_ff
  parameters:
    forward: 'True'
    order: order
    size: vec_len
  states: {}
- name: wavelet_wavelet_ff_1
  id: wavelet_wavelet_ff
  parameters:
    forward: 'False'
    order: order
    size: vec_len
  states: {}
- name: wavelet_wvps_ff_0
  id: wavelet_wvps_ff
  parameters:
    ilen: vec_len
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', wavelet_wavelet_ff_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '1']
- [wavelet_wavelet_ff_0, '0', wavelet_wavelet_ff_1, '0']
- [wavelet_wavelet_ff_0, '0', wavelet_wvps_ff_0, '0']
- [wavelet_wavelet_ff_1, '0', blocks_vector_to_stream_0, '0']
- [wavelet_wvps_ff_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 0.0.0
