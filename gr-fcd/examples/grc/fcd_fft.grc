<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fcd_fft</value></param>
<param><key>title</key><value>Funcube Dongle FFT scope</value></param>
<param><key>author</key><value>Alexandru Csete OZ9AEC</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fcd_freq</value></param>
<param><key>label</key><value>FCD Freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>145.5e6</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fcd_lna_gain</value></param>
<param><key>label</key><value>LNA Gain (dB)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>20</value></param>
<param><key>options</key><value>[30.0, 25.0, 20.0, 17.5, 15.0, 12.5, 10.0, 7.5, 5.0, 2.5, 0.0, -2.5, -5.0]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_1</value></param>
<param><key>device_name</key><value>hw:0</value></param>
<param><key>freq</key><value>fcd_freq</value></param>
<param><key>lna</key><value>fcd_lna_gain</value></param>
<param><key>mixer</key><value>+12</value></param>
<param><key>ppm</key><value>-120</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>fcd_freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<connection><source_block_id>fcd_source_c_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
