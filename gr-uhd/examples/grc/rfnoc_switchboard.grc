options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    copyright: Copyright 2023 Ettus Research, a National Instruments Brand
    description: This example shows how to use the RFNoC Switchboard block
    generate_options: qt_gui
    id: rfnoc_switchboard
    output_language: python
    title: RFNoC Switchboard Example
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 10e6
    step: 1e6
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '35'
    value: '10'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 153.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"type=n3xx"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    num_chans: '2'
    output_rate: samp_rate
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: '0'
    dc_offset: 'False'
    frequency: freq
    gain: gain
    iq_balance: 'False'
    num_chans: '2'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_switchboard_0
  id: uhd_rfnoc_switchboard
  parameters:
    input_port: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_port: '0'
    type: sc16
  states: {}

connections:
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_switchboard_0, '0']
- [uhd_rfnoc_ddc_0, '1', uhd_rfnoc_switchboard_0, '1']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_radio_0, '1', uhd_rfnoc_ddc_0, '1']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_rfnoc_switchboard_0, '0', uhd_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-412-gdaa6e681
