options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    generate_options: qt_gui
    id: rfnoc_duc_radio_multichannel
    output_language: python
    title: 'RFNoC: DUC -> Radio Multichannel Example'
  states: {}

blocks:
- name: freq0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,0,1,1]'
    label: 'Ch0: Frequency (Hz)'
    type: real
    value: 3e9
  states: {}
- name: freq1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,1,1,1]'
    label: 'Ch1: Frequency (Hz)'
    type: raw
    value: 2e9
  states: {}
- name: gain0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,0,1,1]'
    label: 'Ch0: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,1,1,1]'
    label: 'Ch1: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x4xx
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate0
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate0
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: ettus_rfnoc_graph
  id: ettus_rfnoc_graph
  parameters:
    clock_source_0: ''
    clock_source_1: ''
    clock_source_2: ''
    clock_source_3: ''
    clock_source_4: ''
    clock_source_5: ''
    clock_source_6: ''
    clock_source_7: ''
    dev_addr: addr=192.168.30.2
    dev_args: ''
    num_mboards: '1'
    time_source_0: ''
    time_source_1: ''
    time_source_2: ''
    time_source_3: ''
    time_source_4: ''
    time_source_5: ''
    time_source_6: ''
    time_source_7: ''
  states: {}
- name: ettus_rfnoc_tx_radio_0
  id: ettus_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    block_args: ''
    device_select: '-1'
    frequency: freq
    gain: gain
    instance_index: '-1'
    num_chans: '1'
    rate: master_clock_rate
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq0: '0'
    freq1: '0'
    input_rate0: samp_rate0
    input_rate1: samp_rate1
    num_chans: '2'
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: TX/RX
    antenna1: TX/RX
    bandwidth0: '0'
    bandwidth1: '0'
    frequency0: freq0
    frequency1: freq1
    gain0: gain0
    gain1: gain1
    num_chans: '2'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}
- name: uhd_rfnoc_tx_streamer_0_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_rfnoc_tx_streamer_0_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_duc_0, '1', uhd_rfnoc_tx_radio_0, '1']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_duc_0, '0']
- [uhd_rfnoc_tx_streamer_0_0, '0', uhd_rfnoc_duc_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-377-g42fa0be7
