options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    comment: "This is a basic uplink setup using RFNoC, \r\nthat is based on the rfnoc_duc_radio.grc file. \r\nIt transmits two cosine waveform directly \r\nto the antenna. This example demonstrates \r\nthat you can utilize multiple channels with \r\nvarious blocks.\n\nThis program will not work with all USRP. \nIt depends on the daugtherboards that are \nused. Make sure that the daughterboard\nyou are using support two channels TX."
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_duc_radio_multichannel
    output_language: python
    title: 'RFNoC: DUC -> Radio Multichannel Example'
  states: {}

blocks:
- name: freq0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,0,1,1]'
    label: 'Ch0: Frequency (Hz)'
    type: real
    value: 3e9
  states: {}
- name: freq1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,1,1,1]'
    label: 'Ch1: Frequency (Hz)'
    type: raw
    value: 2e9
  states: {}
- name: gain0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,0,1,1]'
    label: 'Ch0: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,1,1,1]'
    label: 'Ch1: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x4xx
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate0
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate0
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq0: '0'
    freq1: '0'
    input_rate0: samp_rate0
    input_rate1: samp_rate1
    num_chans: '2'
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: TX/RX
    antenna1: TX/RX
    bandwidth0: '0'
    bandwidth1: '0'
    frequency0: freq0
    frequency1: freq1
    gain0: gain0
    gain1: gain1
    num_chans: '2'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}
- name: uhd_rfnoc_tx_streamer_0_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [analog_sig_source_x_0_0, '0', uhd_rfnoc_tx_streamer_0_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_tx_radio_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_duc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_tx_radio_0, snk_port_id: '1', src_blk_id: uhd_rfnoc_duc_0, src_port_id: '1'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_duc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_duc_0, snk_port_id: '1', src_blk_id: uhd_rfnoc_tx_streamer_0_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-946-g79c3df96
