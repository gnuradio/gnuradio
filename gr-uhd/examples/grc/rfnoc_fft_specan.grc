options:
  parameters:
    author: mbr0wn
    comment: |-
      To create an FPGA bitfile that can
      run this flow graph, see
      rfnoc_images/x310_image_core_fft.grc.
    generate_options: qt_gui
    id: rfnoc_fft_specan
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable_qtgui_entry
  parameters:
    label: Drop N
    type: int
    value: drop_n
  states: {}
- name: alpha
  id: variable_qtgui_entry
  parameters:
    label: IIR Alpha
    type: real
    value: '0.9'
  states: {}
- name: beta
  id: variable_qtgui_entry
  parameters:
    label: IIR Beta
    type: real
    value: '0.9'
  states: {}
- name: drop_n
  id: variable_qtgui_entry
  parameters:
    label: FFT Ratio (dropped packets)
    type: int
    value: '100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: 100e3
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: device_args
    dev_args: f"master_clock_rate={master_clock_rate}"
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.05'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.7'
    comment: |-
      The Signal Source and the Tx Streamer
      are an alternative source for the FFT,
      using synthetic data. Use this if there is
      no interesting data to be received, or
      you want to sanity-check things.
      To use this, enable this two blocks,
      and disable the radio and DDC blocks.
    freq: '.125'
    offset: '0'
    phase: '0'
    samp_rate: '1'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    comment: |-
      Remember that the FFT block
      will output the mag-square value
      of the FFT as the real value. Here,
      we discard the (unused) imaginary
      value.
    vlen: fft_len
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Note that RFNoC also has a
      Log10 block, and this could
      be also moved to the FPGA.
    k: '0'
    n: '10'
    vlen: fft_len
  states: {}
- name: device_args
  id: parameter
  parameters:
    label: Device Address/Args
    short_id: a
    type: str
    value: ''
  states: {}
- name: fft_len
  id: parameter
  parameters:
    label: FFT Length
    short_id: l
    type: intx
    value: '256'
  states: {}
- name: master_clock_rate
  id: parameter
  parameters:
    label: Master Clock Rate
    short_id: m
    type: eng_float
    value: 200e6
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"FFT Spectrum"'
    vlen: fft_len
    x_axis_label: '"Frequency (Hz)"'
    x_start: freq - master_clock_rate/2
    x_step: master_clock_rate/fft_len
    x_units: '"Hz"'
    y_axis_label: '"10 * log10(|H(f)|^2)"'
    y_units: '"dB"'
    ymin: '-80'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    comment: |-
      If your FPGA configuration does not have
      a DDC block after the radio, simply bypass
      this block.
      You can also change the output rate to enable
      the resample, and show the spectrum of a
      smaller segment of bandwidth.
    freq0: '0'
    output_rate0: master_clock_rate
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    comment: |-
      This FFT block is set to Mag-Squared Mode,
      which means it will output the magnitude squared
      and not the complex value.
      For simplicity, the block will output the mag-square
      value as the real value, and the imaginary value
      becomes zero.
      This flow graph has now windowing, so expect the
      wide sidelobes of a rectangular window!
    fft_direction: FORWARD
    fft_length: '256'
    fft_magnitude: MAGNITUDE_SQUARED
    fft_scaling: '0'
    fft_scaling_factor: 1.0/16
    fft_shift_config: NORMAL
    version: '2'
  states: {}
- name: uhd_rfnoc_keep_one_in_n_0
  id: uhd_rfnoc_keep_one_in_n
  parameters:
    comment: |-
      This block throws away FFT results
      so that only every N-th packet is
      allowed through. Together with
      the Vector-IIR block, this provides
      both an averaging and reduced 
      data rate.
    mode: PACKET
    n: N
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: TX/RX
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    instance_index: '1'
    iq_balance0: 'False'
    rate: master_clock_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    comment: |-
      Because the output of the FFT
      effectively creates vectors, we
      set the vector length to the
      FFT length. That way, in GNU Radio,
      we can deal with full FFT results as
      vectors.
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
    vlen: fft_len
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {state: disabled}
- name: uhd_rfnoc_vector_iir_0
  id: uhd_rfnoc_vector_iir
  parameters:
    alpha: alpha
    beta: beta
    comment: |-
      This block averages the outputs
      of the FFT (bin-wise).
      Remember this is all fixed-point.
      Too aggressive values here can
      lead to really low values at the
      output.
    delay: fft_len
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [blocks_complex_to_real_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_1, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_fft_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_vector_iir_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_fft_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_keep_one_in_n_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', blocks_complex_to_real_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_fft_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_keep_one_in_n_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_vector_iir_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-909-g3a94e076
