options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    description: This shows the PDU capabilities of the RFNoC TX Streamer
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_duc_radio
    output_language: python
    title: 'RFNoC: PDU Example'
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: burst_duration_ms
  id: variable
  parameters:
    value: '100'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: metadata
  id: variable
  parameters:
    comment: |-
      This is the metadata for the signal burst.
      In this example, we set the EOB flag for
      the burst, which is not strictly necessary,
      as the EOB flag is set by default, but it
      shows how to add metadata with the signal.
    value: 'pmt.to_pmt({"tx_eob": True})'
  states: {}
- name: radio_chan
  id: variable
  parameters:
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: signal
  id: variable
  parameters:
    comment: |-
      This is the actual signal data (the samples)
      that will get transmitted with every burst.
      Here, we generate a sinusoid with Numpy
      and then transmit the same signal with every
      burst.
    value: amplitude * np.exp(2 * np.pi * 1j * np.arange(int(burst_duration_ms / 1e3*samp_rate)) * (tone_freq/samp_rate), dtype=np.complex64)
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: 1e6/16
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    comment: |-
      Modify the device address here
      to target your specific USRP.
    dev_addr: type=x300
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      This block will send the signal out once
      every second. In a real application, the
      signal would likely not always be the same,
      and may be sent at any given time.
    msg: ' pmt.cons(metadata, pmt.to_pmt(signal))'
    period: '1000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq0: '0'
    input_rate0: samp_rate
    instance_index: radio_chan
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: TX/RX
    bandwidth0: '0'
    frequency0: freq
    gain0: gain
    instance_index: radio_chan
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    num_chans: '0'
    otw: sc16
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uhd_rfnoc_tx_streamer_0, in]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_tx_radio_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_duc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_duc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-999-g4548e3ab
