options:
  parameters:
    author: Jonathon Pendlum
    category: Custom
    generate_options: qt_gui
    id: rfnoc_radio_window
    output_language: python
    title: 'RFNoC: Window Example'
  states: {}

blocks:
- name: coeffs
  id: variable
  parameters:
    value: getattr(window, qt_window_chooser)(num_coeffs)
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: num_coeffs
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: qt_window_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Window Type
    label0: Blackman-Harris
    label1: Hanning
    label2: Flat Top
    label3: Triangle
    num_opts: '4'
    option0: blackmanharris
    option1: hanning
    option2: flattop
    option3: bartlett
    type: string
    value: blackmanharris
    widget: radio_buttons
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: device_type
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 1+1j
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 1,0,32,1
    label1: I
    label2: Q
    size: num_coeffs
    srate: '1'
    tr_delay: '2048'
    tr_level: '0.999'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}
- name: uhd_rfnoc_window_0
  id: uhd_rfnoc_window
  parameters:
    coeffs_float0: coeffs
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_window_0, '0']
- [uhd_rfnoc_window_0, '0', uhd_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-g1699c828
