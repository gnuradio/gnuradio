options:
  parameters:
    author: Example
    category: Custom
    description: UHD FFT Waveform Plotter
    generate_options: qt_gui
    id: uhd_fft
    output_language: python
    title: UHD FFT
  states: {}

blocks:
- name: ant
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,2,1,2
    label: Antenna
    label0: RX2
    label1: TX/RX
    label2: J1
    label3: J2
    num_opts: '4'
    option0: RX2
    option1: TX/RX
    option2: J1
    option3: J2
    type: string
    value: antenna
  states: {}
- name: chan0_lo_locked
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    function_args: '"''lo_locked''"'
    function_name: get_sensor
    poll_rate: '10'
    value: uhd.sensor_value("", False, "", "")
  states: {state: disabled}
- name: current_freq_c
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    function_args: '"''lo_locked''"'
    function_name: get_sensor
    poll_rate: '10'
    value: freq_c
  states: {state: disabled}
- name: freq_c
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0,1,2
    label: RX Tune Frequency
    type: real
    value: freq
  states: {}
- name: gain_
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.5'
    stop: '31.5'
    value: gain
  states: {}
- name: lo_locked_probe
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,0,1,2
    label: LO locked
    type: bool
    value: chan0_lo_locked.to_bool()
  states: {state: disabled}
- name: samp_rate_
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,2,1,2
    label: Sampling Rate
    type: real
    value: samp_rate
  states: {}
- name: uhd_version_info
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: UHD Version
    type: string
    value: uhd.get_version_string()
  states: {}
- name: usrp_device_info
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,2,1,2
    label: Device Information
    type: raw
    value: uhd.get_version_string()
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    short_id: A
    value: '"RX2"'
  states: {}
- name: args
  id: parameter
  parameters:
    label: UHD device address args
    short_id: a
    value: '""'
  states: {}
- name: display
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: Spectrum
    label1: Waterfall
    label2: Scope
    num_tabs: '3'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: Set number of FFT bins
    type: intx
    value: '1024'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 2.45e9
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Set gain in dB (default is midpoint)
    short_id: g
    type: eng_float
    value: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate_
    ctrlpanel: 'True'
    fc: freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: display@0:0,0,1,4
    legend: 'False'
    name: ''
    type: complex
    update_time: update_rate
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: display@2:0,0,1,4
    label1: ''
    label2: ''
    legend: 'False'
    name: ''
    size: '1024'
    srate: samp_rate_
    type: complex
    update_time: update_rate
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_
    fc: freq
    fftsize: '1024'
    gui_hint: display@1:0,0,1,4
    name: ''
    showports: 'True'
    type: complex
    update_time: update_rate
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 1e6
  states: {}
- name: spec
  id: parameter
  parameters:
    label: Subdev
    value: '""'
  states: {}
- name: stream_args
  id: parameter
  parameters:
    label: Set additional stream args
    value: '""'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ant
    bw0: samp_rate
    center_freq0: float(freq_c)
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: args
    dev_args: '""'
    gain0: gain_
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_
    sd_spec0: spec
    stream_args: stream_args
    sync: sync
    type: fc32
  states: {}
- name: update_rate
  id: parameter
  parameters:
    label: Set GUI widget update rate
    type: eng_float
    value: '.1'
  states: {}
- name: wire_format
  id: parameter
  parameters:
    label: Wire format
    value: '""'
  states: {}

connections:
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
