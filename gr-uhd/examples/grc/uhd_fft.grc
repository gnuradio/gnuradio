<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_fft</value></param>
<param><key>title</key><value>UHD FFT</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>UHD FFT Waveform Plotter</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_gain</value></param>
<param><key>label</key><value>Default Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>IP Address</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>display</value></param>
<param><key>num_tabs</key><value>3</value></param>
<param><key>label0</key><value>Spectrum</value></param>
<param><key>label1</key><value>Waterfall</value></param>
<param><key>label2</key><value>Scope</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31.5</value></param>
<param><key>step</key><value>.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,2,1,2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>RX Tune Frequency</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>6e9</value></param>
<param><key>step</key><value>100e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ant</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>value</key><value>RX2</value></param>
<param><key>option0</key><value>RX2</value></param>
<param><key>label0</key><value>RX2</value></param>
<param><key>option1</key><value>TX/RX</value></param>
<param><key>label1</key><value>TX/RX</value></param>
<param><key>option2</key><value>J1</value></param>
<param><key>label2</key><value>J1</value></param>
<param><key>option3</key><value>J2</value></param>
<param><key>label3</key><value>J2</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lo_locked_probe</value></param>
<param><key>label</key><value>LO locked</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>chan0_lo_locked.to_bool()</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>chan0_lo_locked</value></param>
<param><key>value</key><value>uhd.sensor_value("", False, "")</value></param>
<param><key>block_id</key><value>uhd_usrp_source_0</value></param>
<param><key>function_name</key><value>get_sensor</value></param>
<param><key>function_args</key><value>"'lo_locked'"</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>display@2:3,0,1,4</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>ant</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>display@1:3,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>display@0:3,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
