options:
  parameters:
    author: Zach Rohde <zachary.s.rohde@jpl.nasa.gov>
    description: This example shows how to use the RFNoC Null Source Sink block
    generate_options: qt_gui
    id: rfnoc_null_source_sink
    output_language: python
    title: RFNoC Null Source Sink Example
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x300
  states: {}
- name: uhd_rfnoc_null_src_sink_0
  id: uhd_rfnoc_null_src_sink
  parameters:
    btype: source
  states: {}
- name: uhd_rfnoc_null_src_sink_0_0
  id: uhd_rfnoc_null_src_sink
  parameters: {}
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    iq_balance0: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: TX/RX
    bandwidth0: '0'
    frequency0: freq
    gain0: gain
    rate: radio_rate
  states: {}

connections:
- [uhd_rfnoc_null_src_sink_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_null_src_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-1-g6a62c345
