options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    comment: |-
      The program demonstrates the functionality of the Fast Add-Subtract Block, which 
      performs addition and subtraction of two cosine signals. As a result, six signals are 
      displayed as output:
      1. The sum of both cosine signals
      2. The first cosine signal
      3. The second cosine signal
      4. The result of subtracting the first cosine signal from the second cosine signal
      5. The first cosine signal (repeated for clarity)
      6. The second cosine signal (repeated for clarity)
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_addsub
    output_language: python
    title: 'RFNoC: AddSub Example'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.40.2"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.65'
    freq: samp_rate/32
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.25'
    freq: samp_rate/32
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sum I
    label2: Sum Q
    label3: Signal 1 I
    label4: Signal 1 Q
    label5: Signal 2 I
    label6: Signal 2 Q
    name: '"Sum"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    style3: '2'
    style4: '2'
    style5: '2'
    style6: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Difference I
    label2: Difference Q
    label3: Signal 1 I
    label4: Signal 1 Q
    label5: Signal 2 I
    label6: Signal 2 Q
    name: '"Difference"'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    style3: '2'
    style4: '2'
    style5: '2'
    style6: '2'
    type: complex
  states: {}
- name: uhd_rfnoc_addsub_0
  id: uhd_rfnoc_addsub
  parameters: {}
  states: {}
- name: uhd_rfnoc_rx_streamer_1
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    num_chans: '2'
    otw: sc16
    output_type: fc32
    start_time_set: 'True'
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    num_chans: '2'
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [blocks_throttle2_0, '0', uhd_rfnoc_tx_streamer_0, '1']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_throttle2_1, '0', uhd_rfnoc_tx_streamer_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_1, snk_port_id: '0', src_blk_id: uhd_rfnoc_addsub_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_1, snk_port_id: '1', src_blk_id: uhd_rfnoc_addsub_0, src_port_id: '1'}
- [uhd_rfnoc_rx_streamer_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [uhd_rfnoc_rx_streamer_1, '1', qtgui_time_sink_x_0_0_0_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_addsub_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_addsub_0, snk_port_id: '1', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '1'}

metadata:
  file_format: 2
  grc_version: 3.6.1git-10498-g32ddbd1c
