options:
  parameters:
    category: Custom
    description: Tune a UHD source from a QT sink via messages (double-click a frequency to tune)
    generate_options: qt_gui
    id: uhd_tune_msg
    output_language: python
    title: UHD Message Tuner
  states: {}

blocks:
- name: ant_msg
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    num_opts: '2'
    option0: TX/RX
    option1: RX2
    type: string
    value: TX/RX
  states: {}
- name: cmd_msg
  id: variable
  parameters:
    value: 'pmt.to_pmt({''antenna'': ant_msg, ''gain'': gain_msg, ''chan'': 0, ''freq'': freq_msg, ''lo_offset'': lo_msg})'
  states: {}
- name: freq_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    type: real
    value: initial_fc
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: gain_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    type: real
    value: gain
  states: {}
- name: initial_fc
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: lo_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: LO Offset
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: cmd_msg
    period: '2000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: initial_fc
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: ''
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: initial_fc
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uhd_usrp_source_0, command]
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
