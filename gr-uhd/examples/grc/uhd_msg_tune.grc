options:
  parameters:
    category: Custom
    description: Tune a UHD source from a QT sink via messages (double-click a frequency to tune)
    generate_options: qt_gui
    id: uhd_tune_msg
    output_language: python
    title: UHD Message Tuner
  states: {}

blocks:
- name: ant_msg
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    num_opts: '2'
    option0: TX/RX
    option1: RX2
    type: string
    value: TX/RX
  states: {}
- name: freq_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency
    type: real
    value: initial_fc
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gain_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    type: real
    value: gain
  states: {}
- name: initial_fc
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: lo_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: LO Offset
    type: real
    value: '0'
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Args
    short_id: a
    type: str
    value: ''
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      This message print is
      just to show what's going on.
      Any message generated by any block
      will be shown here.
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: freq
    target: freq_msg
  states: {}
- name: blocks_var_to_msg_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: gain
    target: gain_msg
  states: {}
- name: blocks_var_to_msg_0_0_0
  id: blocks_var_to_msg
  parameters:
    comment: |-
      These blocks monitor the state of
      variables and create a message when
      they change.
      The variables are set by the QT GUI widgets.
    msgname: antenna
    target: ant_msg
  states: {}
- name: blocks_var_to_msg_0_0_0_0
  id: blocks_var_to_msg
  parameters:
    msgname: lo_offset
    target: lo_msg
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: |-
      The freq output of this block is
      in fact also connected to its freq
      input. This allows updating the
      x-axis when it's double-clicked.
    fc: initial_fc
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    name: ''
    showports: 'True'
    type: complex
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate
    short_id: r
    type: eng_float
    value: 2e6
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Subdev Spec
    short_id: s
    type: str
    value: ''
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: initial_fc
    clock_rate: '0.0'
    dev_addr: args
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0, msgout, qtgui_freq_sink_x_0, freq]
- [blocks_var_to_msg_0, msgout, uhd_usrp_source_0, command]
- [blocks_var_to_msg_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0, msgout, uhd_usrp_source_0, command]
- [blocks_var_to_msg_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0, msgout, uhd_usrp_source_0, command]
- [blocks_var_to_msg_0_0_0_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0_0_0_0, msgout, uhd_usrp_source_0, command]
- [qtgui_freq_sink_x_0, freq, blocks_message_debug_0, print]
- [qtgui_freq_sink_x_0, freq, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, async_msgs, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-892-g6406da8f
