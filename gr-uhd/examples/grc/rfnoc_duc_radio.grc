options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    generate_options: qt_gui
    id: rfnoc_duc_radio
    output_language: python
    title: 'RFNoC: Radio -> DDC Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: tone_freq
  id: variable_qtgui_entry
  parameters:
    label: Baseband Tone Frequency (Hz)
    type: real
    value: samp_rate/16
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x300
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq: '0'
    input_rate: samp_rate
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    agc: Default
    antenna: TX/RX
    bandwidth: '0'
    frequency: freq
    gain: gain
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [uhd_rfnoc_duc_0, '0', uhd_rfnoc_tx_radio_0, '0']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_duc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-299-gf11a567f
