options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_duc_radio
    output_language: python
    title: 'RFNoC: Radio -> DDC Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: radio_chan
  id: variable
  parameters:
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: |-
      This variable must match the master clock rate
      of this device.
    value: 200e6
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: tone_freq
  id: variable_qtgui_entry
  parameters:
    label: Baseband Tone Frequency (Hz)
    type: real
    value: samp_rate/16
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    comment: |-
      This example is designed to be run with
      a standard RFNoC bitfile. It may also work
      with other bitfiles, but it does require a DUC
      and Radio to be connectable.
    dev_addr: type=x300
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    comment: |-
      This and the radio block use radio_chan to
      select the desired radio block (e.g., set this
      to '1' on a USRP X310 series to select the B-side).
    freq0: '0'
    input_rate0: samp_rate
    instance_index: radio_chan
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: TX/RX
    bandwidth0: '0'
    frequency0: freq
    gain0: gain
    instance_index: radio_chan
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_tx_radio_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_duc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_duc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-999-g4548e3ab
