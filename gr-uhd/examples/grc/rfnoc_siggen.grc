options:
  parameters:
    author: Brian Padalino
    category: Custom
    description: Example of using the RFNoC SigGen Block
    generate_options: qt_gui
    id: rfnoc_siggen
    output_language: python
    title: RFNoC SigGen Example
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: (2, 0, 1, 1)
    label: amp
    orient: QtCore.Qt.Orientation.Horizontal
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: enable
  id: variable_qtgui_check_box
  parameters:
    comment: |-
      Note: You have to click the 'enable'
      box for data to run through this
      flow graph!
    'false': 'False'
    gui_hint: (0,0,1,1)
    label: enable
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,1)
    label: tone_freq
    orient: QtCore.Qt.Orientation.Horizontal
    outputmsgname: value
    showports: 'False'
    start: '-fs/2'
    step: '1'
    stop: fs/2
    value: fs/4
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: device_type
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    gui_hint: (3,0,1,1)
    label1: SigGen
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (4,0,1,1)
    label1: Re
    label2: Im
    size: '1024'
    srate: fs
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.uhd_rfnoc_siggen_0.set_enable(False, 0);
    comment: Automatically disables SigGen output when ending flowgraph
    section: main_after_stop
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_siggen_0
  id: uhd_rfnoc_siggen
  parameters:
    enable0: enable
    sample_rate0: fs
    signal_amplitude0: amp
    signal_frequency0: tone_freq
    signal_type0: SINE_WAVE
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_throttle_0, '0']
- [uhd_rfnoc_siggen_0, '0', uhd_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-233-g1699c828
