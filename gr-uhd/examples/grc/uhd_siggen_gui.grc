options:
  parameters:
    author: Ettus Research
    category: Custom
    description: 'Signal Generator for use with USRP Devices. Note: The application uhd_siggen_gui is a much more sophisticated version of this flowgraph!'
    generate_options: qt_gui
    id: uhd_siggen_gui
    output_language: python
    title: UHD Signal Generator
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,5
    label: Signal Amplitude
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.001'
    stop: '1'
    value: '.7'
  states: {}
- name: ant
  id: variable_qtgui_entry
  parameters:
    label: TX Antenna
    type: string
    value: TX/RX
  states: {}
- name: freq1_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: 'Frequency Offset: Signal 1'
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: '0'
  states: {}
- name: freq2_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,2
    label: 'Signal 2 '
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: 100e3
  states: {}
- name: freq_coarse
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,5
    label: Center Frequency
    orient: QtCore.Qt.Orientation.Horizontal
    start: 100e6
    step: 1e3
    stop: 2e9
    value: tx_freq
  states: {}
- name: freq_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,5
    label: Fine Tuning
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-1e6'
    step: 1e3
    stop: 1e6
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,5
    label: TX Gain
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.5'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 7,0,1,2
    label: Sampling Rate
    type: real
    value: 1e6
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,5
    label: Waveform
    label0: Constant
    label1: Complex Sinusoid
    label2: Gaussian Noise
    label3: Uniform Noise
    label4: Two-Tone
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: amplitude if waveform in (2,3) else 0
    noise_type: '{0: analog.GR_GAUSSIAN, 1: analog.GR_GAUSSIAN, 2: analog.GR_GAUSSIAN, 3: analog.GR_UNIFORM, 4: analog.GR_GAUSSIAN}[waveform]'
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude if waveform in (0, 1, 4) else 0
    freq: freq1_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: '{0: analog.GR_CONST_WAVE, 1: analog.GR_COS_WAVE, 2: analog.GR_CONST_WAVE, 3: analog.GR_CONST_WAVE, 4: analog.GR_COS_WAVE}[waveform]'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude if waveform == 4 else 0
    freq: freq2_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: '{0: analog.GR_CONST_WAVE, 1: analog.GR_COS_WAVE, 2: analog.GR_CONST_WAVE, 3: analog.GR_CONST_WAVE, 4: analog.GR_COS_WAVE}[waveform]'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: dev_addr
  id: parameter
  parameters:
    label: Device Address
    short_id: a
    type: str
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_coarse + freq_fine
    fftsize: '1024'
    gui_hint: 9,0,2,5
    showports: 'True'
    type: complex
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Subdev Spec
    short_id: s
    type: str
    value: A:0
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    label: Initial TX frequency
    short_id: f
    type: eng_float
    value: 1e9
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ant
    center_freq0: freq_coarse + freq_fine
    clock_rate: '0.0'
    dev_addr: dev_addr
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-892-g6406da8f
