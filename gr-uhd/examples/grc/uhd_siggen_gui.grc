options:
  parameters:
    author: Ettus Research
    category: Custom
    description: Signal Generator for use with USRP Devices
    generate_options: qt_gui
    id: uhd_siggen_gui
    output_language: python
    title: UHD Signal Generator
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,5
    label: Signal Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '1'
    value: '.7'
  states: {}
- name: ant
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 7,4,1,1
    label: Antenna
    label0: RX2
    label1: TX/RX
    num_opts: '2'
    option0: RX2
    option1: TX/RX
    type: string
    value: RX2
  states: {}
- name: chan0_lo_locked
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_sink_0
    function_args: '"''lo_locked''"'
    function_name: get_sensor
    poll_rate: '10'
    value: uhd.sensor_value("", False, "", "")
  states: {}
- name: freq1_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: 'Frequency Offset: Signal 1'
    orient: Qt.Horizontal
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: '0'
  states: {}
- name: freq2_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,3,1,2
    label: 'Signal 2 '
    orient: Qt.Horizontal
    start: '-1e6'
    step: '100'
    stop: 1e6
    value: '0'
  states: {}
- name: freq_coarse
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,5
    label: Center Frequency
    orient: Qt.Horizontal
    start: 100e6
    step: 1e3
    stop: 2e9
    value: 1e9
  states: {}
- name: freq_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,5
    label: Fine Tuning
    orient: Qt.Horizontal
    start: '-1e6'
    step: 1e3
    stop: 1e6
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,5
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.5'
    stop: '50'
    value: '20'
  states: {}
- name: label_dsp_freq
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,2,1,1
    label: DSP Freq
    type: real
    value: 1e3
  states: {}
- name: label_lo_freq
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,1,1,1
    label: LO freq
    type: real
    value: 1e9
  states: {}
- name: lo_locked_probe_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,0,1,1
    label: LO locked
    type: bool
    value: chan0_lo_locked.to_bool()
  states: {}
- name: lo_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,5
    label: LO Offset
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/2
    stop: 1e3
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 7,0,1,2
    label: Sampling Rate
    type: real
    value: 1e6
  states: {}
- name: sync_phases
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 7,2,1,1
    label: Sync LOs
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,5
    label: Waveform
    label0: Tone
    label1: Two-Tone
    label2: Uniform Noise
    label3: Two Tone
    label4: Sweep
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude if not sync_phases else 0
    freq: freq1_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_coarse + freq_fine
    fftsize: '1024'
    gui_hint: 9,0,2,5
    showports: 'True'
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: '0'
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
