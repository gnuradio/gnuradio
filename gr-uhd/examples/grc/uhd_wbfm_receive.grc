options:
  parameters:
    author: Example
    category: Custom
    description: WBFM Receive
    generate_options: qt_gui
    id: uhd_wbfm_receive
    output_language: python
    title: UHD WBFM Receive
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,1,1
    label: Antenna
    label0: '"RX2"'
    label1: '"TX/RX"'
    num_opts: '2'
    option0: '"RX2"'
    option1: '"TX/RX"'
    type: string
    value: '"RX2"'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 93.3e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      CCIR Band

      If in Italy, change Step size to 50e3
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 87.5e6
    step: 100e3
    stop: 108e6
    value: freq
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    comment: Japan FM Band
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 76e6
    step: 100e3
    stop: 95e6
    value: freq
  states: {state: disabled}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    comment: OIRT Band
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 65.8e6
    step: 30e3
    stop: 74e6
    value: freq
  states: {state: disabled}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: UHD Gain
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.1'
    stop: '1'
    value: '.5'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 5
    label: Volume
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: samp_rate
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: device_args
  id: parameter
  parameters:
    label: Device Args
    short_id: a
    value: '""'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 115e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_HANN
  states: {}
- name: note_0
  id: note
  parameters:
    comment: Enable only one frequency range for your location
    note: Enable/Display tun_freq
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tun_freq
    fftsize: '512'
    gui_hint: 3,0,2,5
    legend: 'False'
    name: ''
    showports: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    center_freq0: tun_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: device_args
    dev_args: '""'
    gain0: tun_gain
    gain_type0: normalized
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv, '0', blocks_multiply_const_vxx, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
