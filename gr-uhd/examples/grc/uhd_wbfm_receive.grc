options:
  parameters:
    author: Example
    category: Custom
    description: WBFM Receive
    generate_options: qt_gui
    id: uhd_wbfm_receive
    output_language: python
    title: UHD WBFM Receive
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Fine Freq (MHz)
    orient: Qt.Horizontal
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: '0'
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: UHD Freq (MHz)
    orient: Qt.Horizontal
    start: '87.9'
    step: '1'
    stop: '108.1'
    value: freq/1e6
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    label: UHD Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 4
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: address
  id: parameter
  parameters:
    label: IP Address
    short_id: a
    value: addr=192.168.10.2
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: samp_rate
  states: {}
- name: audio_output
  id: parameter
  parameters:
    label: Audio Output Device
    short_id: O
    value: ''
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: audio_output
    samp_rate: int(samp_rate/audio_decim)
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 93.3e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Default Gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 115e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: firdes.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: (tun_freq+fine)*1e6
    fftsize: '512'
    gui_hint: 2,0,2,4
    legend: 'False'
    name: ''
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 400e3
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: (tun_freq+fine)*1e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: address
    dev_args: '""'
    gain0: tun_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv, '0', blocks_multiply_const_vxx, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
