options:
  parameters:
    category: Custom
    description: Works with any device and gain range!
    generate_options: qt_gui
    id: uhd_normalized_gain
    output_language: python
    title: Example to showcase absolute vs. relative gain settings
  states: {}

blocks:
- name: abs_gain
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    function_args: '0'
    function_name: get_gain
    poll_rate: '10'
    value: '5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Normalized Gain
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.02'
    stop: '1'
    value: '.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: Absolute Gain
    type: real
    value: abs_gain
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: 1e9
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
