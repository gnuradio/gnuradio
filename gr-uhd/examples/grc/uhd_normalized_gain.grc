<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_normalized_gain</value></param>
<param><key>title</key><value>Example to showcase absolute vs. relative gain settings</value></param>
<param><key>description</key><value>Works with any device and gain range!</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>label</key><value>Absolute Gain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>abs_gain</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1e9</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Normalized Gain</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>.02</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>abs_gain</value></param>
<param><key>value</key><value>5</value></param>
<param><key>block_id</key><value>uhd_usrp_source_0</value></param>
<param><key>function_name</key><value>get_gain</value></param>
<param><key>function_args</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
