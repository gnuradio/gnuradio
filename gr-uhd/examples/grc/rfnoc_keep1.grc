options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    category: Custom
    generate_options: qt_gui
    id: rfnoc_radio_window
    output_language: python
    title: 'RFNoC: Keep-one-in-N Example'
  states: {}

blocks:
- name: device_type
  id: variable
  parameters:
    value: '"type=x300"'
  states: {}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: n
  id: variable_qtgui_entry
  parameters:
    comment: |-
      This entry widgets lets you select how many samples
      to decimate by. If you set it to 1, it won't decimate.
      Set it to 2, it will decimate by 2 and so on.
    label: N
    type: int
    value: '2'
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: device_type
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/100
    offset: '0'
    phase: '0'
    samp_rate: '1.0'
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      This scope is configured to show 2 full saw tooth
      phases, when the decimation is set to 1.
    entags: 'False'
    grid: 'True'
    gui_hint: 1,0,32,1
    label1: I
    label2: Q
    size: '200'
    srate: '1'
    tr_level: 1/100
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    fft_direction: FORWARD
    fft_length: '256'
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_fft_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_fft_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: 3.10.10.0
