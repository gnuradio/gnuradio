options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    comment: |-
      This is a basic downlink setup using
      RFNoC. It receives signals and displays
      them with a Frequency sink.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_radio_ddc
    output_language: python
    title: 'RFNoC: Radio -> DDC Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    start: '0'
    step: 1e8
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample rate
    start: 1e5
    step: 1e6
    stop: 200e6
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x4xx
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: '0'
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    iq_balance0: 'False'
    rate: samp_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}

connections:
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-946-g79c3df96
