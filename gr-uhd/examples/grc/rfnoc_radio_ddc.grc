options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_radio_ddc
    output_language: python
    title: 'RFNoC: Radio -> DDC Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: args
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Address
    short_id: a
    type: str
    value: type=x300,addr=192.168.30.2
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      This is just for visualization purposes,
      it will show the message that is sent
      to the motherboard controller block.
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: |-
      This will show an input field, into
      which the user can type valid time sources,
      such as external, internal, gpsdo, etc.

      When updating the time source and hitting
      enter, a message is sent to the motherboard
      controller block which causes the time source
      to update.
    key: time_source
    label: Time Source
    type: string
    value: internal
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: '0'
  states: {}
- name: uhd_rfnoc_mb_controller_0
  id: uhd_rfnoc_mb_controller
  parameters:
    clock_source: ''
    comment: |-
      This is an optional block, which allows more
      fine-grained control over the USRP hardware.
      It can be used to configure options that are
      not tied to individual RFNoC blocks, e.g., the
      clock or time source, or the current time.
    mb_index: uhd.rfnoc_mb_controller.ALL_MBOARDS
    set_time_now: '-1'
    time_source: ''
    timekeeper_idx: '0'
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: A
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: 1e9
    gain0: '0'
    iq_balance0: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}

connections:
- [qtgui_edit_box_msg_0, msg, blocks_message_debug_0, print]
- [qtgui_edit_box_msg_0, msg, uhd_rfnoc_mb_controller_0, command]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- [uhd_rfnoc_graph, mbc, uhd_rfnoc_mb_controller_0, g]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-1000-g7bfb8d06
