options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    generate_options: qt_gui
    id: rfnoc_radio_ddc
    output_language: python
    title: 'RFNoC: Radio -> DDC Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sampling Rate (Hz)
    type: real
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x300,addr=192.168.10.2
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    output_rate: samp_rate
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: '0'
    dc_offset: 'False'
    frequency: freq
    gain: gain
    iq_balance: 'False'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}

connections:
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
