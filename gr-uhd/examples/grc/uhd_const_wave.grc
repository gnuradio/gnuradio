options:
  parameters:
    author: Example
    category: Custom
    description: Tune UHD Device
    generate_options: qt_gui
    id: uhd_const_wave
    output_language: python
    title: UHD Constant Wave
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: tun_freq
  id: variable_qtgui_range
  parameters:
    label: UHD Freq (Hz)
    orient: Qt.Orientation.Horizontal
    start: 2.4e9
    step: '1'
    stop: 2.5e9
    value: 2.45e9
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    label: UHD Gain
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: address
  id: parameter
  parameters:
    label: IP Address
    short_id: a
    value: '"addr=192.168.10.2"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: ampl
    type: complex
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Default Frequency
    short_id: f
    type: eng_float
    value: 2.45e9
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Default Gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: s
    type: eng_float
    value: 1e6
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: tun_freq
    clock_rate: '0.0'
    dev_addr: address
    dev_args: '""'
    gain0: tun_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
