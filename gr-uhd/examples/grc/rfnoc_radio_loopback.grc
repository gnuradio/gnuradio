options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    copyright: (C) 2023 Ettus Research, a National Instruments Brand
    description: This flowgraph demonstrated RFNoC loopback capabilities on a single device. It assumes a default FPGA bitfile, which includes DDC and DUC blocks. It allows receiving on one frequency, and re-transmitting on another (bent-pipe).
    generate_options: qt_gui
    id: rfnoc_radio_loopback
    output_language: python
    title: 'RFNoC: Radio Loopback Example'
  states: {}

blocks:
- name: dev_addr
  id: variable
  parameters:
    value: '''type=x300'''
  states: {}
- name: master_clock_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: rx_ant
  id: variable_qtgui_entry
  parameters:
    label: RX Antenna
    type: string
    value: '"RX2"'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Note: None of these are probed from the hardware, so the available
      gain and frequency ranges may not be actually available.
    label: RX Frequency (Hz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: 1e6
    stop: 7.2e9
    value: 1e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: rx_slot
  id: variable
  parameters:
    comment: |-
      These 'slot' variables are used for the 'instance' parameter of the various blocks.
      If you want to receive on 0/Radio#0, and transmit on 0/Radio#1, set rx_slot and tx_slot to 0 and 1, respectively.
      If both are the same, also read the comment under the TX Radio block.
    value: '0'
  states: {}
- name: stream_cmd_dict
  id: variable
  parameters:
    value: '{''stream_now'': True, ''stream_mode'': ''start_cont'' if stream_on else ''stop_cont''}'
  states: {}
- name: stream_on
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: |-
      All of this is simply to provide a toggle switch to turn loopback on and off.
      By default, the RFNoC RX Radio does not stream, it waits for a stream command.
      In this flow graph, we provide that stream command manually, through the
      command message port.
    initPressed: 'False'
    label: Enable Stream
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tx_ant
  id: variable_qtgui_entry
  parameters:
    label: TX Antenna
    type: string
    value: '"TX/RX"'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequency (Hz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: 1e6
    stop: 7.2e9
    value: 2e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: tx_slot
  id: variable
  parameters:
    value: '1'
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    comment: |-
      To select a specific device, change the dev_addr variable (e.g., 'addr=192.168.30.2', 'type=x4xx', etc.)
      We set the master clock rate separately, because we also use that variable as the sampling rate in the
      radio and resampler blocks.
    dev_addr: dev_addr
    dev_args: '"master_clock_rate=" + str(master_clock_rate)'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      This mini-flowgraph is simply here to keep the flow graph alive from a
      GNU Radio perspective, as none of the other blocks do anything from
      GNU Radio's point of view.
    samples_per_second: 1e5
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: stream_cmd
    target: stream_cmd_dict
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.rfnoc_graph.commit()
    comment: |-
      This code will commit the RFNoC graph before the application starts.
      The RFNoC streamers will handle the comitting of a flow graph, but
      in abscence of streamers, this snippet is a good substitute.
    section: main_after_init
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    comment: |-
      The DDC and DUC blocks do nothing in this application. However, they happen to be
      instantiated in most default bitfiles, so we need to include them here as well.
    freq0: '0'
    instance_index: rx_slot
    output_rate0: master_clock_rate
  states: {}
- name: uhd_rfnoc_duc_0
  id: uhd_rfnoc_duc
  parameters:
    freq0: '0'
    input_rate0: master_clock_rate
    instance_index: tx_slot
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: rx_ant
    bandwidth0: '0'
    comment: |-
      It is important to disable timestamps for this RX radio.
      The TX radio will interpret timestamps as when to transmit, which
      means all packets would be considered late if timestamps were
      enabled.
    dc_offset0: 'False'
    enable_timestamps0: 'False'
    frequency0: rx_freq
    gain0: rx_gain
    instance_index: rx_slot
    iq_balance0: 'False'
    rate: master_clock_rate
  states: {}
- name: uhd_rfnoc_tx_radio_0
  id: uhd_rfnoc_tx_radio
  parameters:
    antenna0: tx_ant
    bandwidth0: '0'
    comment: |-
      NOTE! If the TX Radio and the RX Radio
      are the same, then we have a loop in the 
      RFNoC graph. This is allowed, but we have
      to declare one of these edges a back-edge.

      To do so, simply right-click the green arrow 
      going into this TX Radio, and set the back-edge
      property to 'True'.
    frequency0: tx_freq
    gain0: tx_gain
    instance_index: tx_slot
    rate: master_clock_rate
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [blocks_var_to_msg_0, msgout, uhd_rfnoc_rx_radio_0, command]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_duc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: rx_slot == tx_slot}, snk_blk_id: uhd_rfnoc_tx_radio_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_duc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-587-gf73f8f07
