options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    comment: |-
      The program demonstrates the use of the RFNoC Replay
      Block along with the Replay Msg Push Button Block. These
      blocks are typically used together to manage the recording 
      and replaying of data. Commands to the Replay Block, such 
      as 'record' or 'play', are sent using dictionary keys with 
      'command' being the required key. The Replay Msg Push 
      Button simplifies sending these commands.
    copyright: Copyright 2023 Ettus Research, a National Instruments Brand
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_replay
    output_language: python
    title: RFNoC Replay Example
  states: {}

blocks:
- name: play_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,2,1,1]'
    label: Play Offset
    type: int
    value: '0'
  states: {}
- name: play_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ':[2,2,1,1]'
    label: Play Port
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: play_size
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,3,1,1]'
    label: Play Size
    type: int
    value: '80000'
  states: {}
- name: record_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,0,1,1]'
    label: Record Offset
    type: int
    value: '0'
  states: {}
- name: record_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ':[2,1,1,1]'
    label: Record Port
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: record_size
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,1,1,1]'
    label: Record Size
    type: int
    value: '80000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.40.2"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      This will print out the record fullness to the 
      terminal when the record fullness button is pressed. 
      This helps indicate to the user if the block has 
      finished recording the requested amount.
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cont_play_push_button
  id: uhd_msg_push_button
  parameters:
    command: play
    gui_hint: ':[1,2,1,1]'
    label: Play Continuous
    port: play_port
    repeat: 'True'
  states: {}
- name: fullness_push_button
  id: uhd_msg_push_button
  parameters:
    command: get_record_fullness
    gui_hint: ':[2,0,1,1]'
    label: Get Record Fullness
    port: record_port
  states: {}
- name: play_push_button
  id: uhd_msg_push_button
  parameters:
    command: play
    gui_hint: ':[1,1,1,1]'
    label: Play
    port: play_port
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: ':[5,0,1,4]'
    name: Port 0 Output
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: record_push_button
  id: uhd_msg_push_button
  parameters:
    command: record
    gui_hint: ':[1,0,1,1]'
    label: Record
    port: record_port
  states: {}
- name: stop_push_button
  id: uhd_msg_push_button
  parameters:
    command: stop
    gui_hint: ':[1,3,1,1]'
    label: Stop Playback
    port: play_port
  states: {}
- name: uhd_rfnoc_replay_0
  id: uhd_rfnoc_replay
  parameters:
    num_in_ports: '2'
    play_offset0: play_offset
    play_size0: play_size
    play_type0: sc16
    record_offset0: record_offset
    record_offset1: record_offset
    record_size0: record_size
    record_size1: record_size
    record_type0: sc16
    record_type1: sc16
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}
- name: uhd_rfnoc_tx_streamer_0_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [blocks_throttle2_0_0, '0', uhd_rfnoc_tx_streamer_0_0, '0']
- [cont_play_push_button, pressed, uhd_rfnoc_replay_0, command]
- [fullness_push_button, pressed, uhd_rfnoc_replay_0, command]
- [play_push_button, pressed, uhd_rfnoc_replay_0, command]
- [record_push_button, pressed, uhd_rfnoc_replay_0, command]
- [stop_push_button, pressed, uhd_rfnoc_replay_0, command]
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_replay_0, src_port_id: '0'}
- [uhd_rfnoc_replay_0, debug_msgs, blocks_message_debug_0, print]
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_time_sink_x_0, '0']
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_replay_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_tx_streamer_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_replay_0, snk_port_id: '1', src_blk_id: uhd_rfnoc_tx_streamer_0_0, src_port_id: '0'}

metadata:
  file_format: 2
  grc_version: 3.6.1git-10498-g32ddbd1c
