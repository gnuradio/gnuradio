options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    generate_options: qt_gui
    id: rfnoc_fosphor
    output_language: python
    title: 'RFNoC: Fosphor Example'
  states: {}

blocks:
- name: device_type
  id: variable
  parameters:
    value: '"type=n3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=e3xx"'
  states: {state: disabled}
- name: device_type
  id: variable
  parameters:
    value: '"type=x4xx"'
  states: {state: disabled}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fosphor_decim
  id: variable
  parameters:
    value: int(samp_rate / (fft_size * pwr_bins * frame_rate))
  states: {}
- name: frame_rate
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 1e6
    step: 1e6
    stop: 7.2e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '10'
  states: {}
- name: pwr_bins
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(200e6)
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.20.2"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: byte
    vlen: fft_size
  states: {state: disabled}
- name: qtgui_fosphor_display_0
  id: qtgui_rfnoc_f15_display
  parameters:
    center_freq: '50000'
    fftsize: fft_size
    frame_rate: '30'
    grid_enabled: 'True'
    palette: iron
    pwr_bins: pwr_bins
    samp_rate: samp_rate
    wf_enabled: 'True'
    wf_lines: '512'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    output_rate: samp_rate
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    fft_direction: FORWARD
    fft_length: fft_size
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_fosphor_0
  id: uhd_rfnoc_fosphor
  parameters:
    enable_dither: 'True'
    enable_noise: 'True'
    enable_wf: 'True'
    hist_decim: fosphor_decim
    wf_decim: fosphor_decim
    wf_mode: MODE_MAX_HOLD
    wf_prediv: RATIO_1_1
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: '0'
    block_args: f"spp={fft_size}"
    dc_offset: 'False'
    frequency: freq
    gain: gain
    iq_balance: 'False'
    rate: samp_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: s8
    output_type: s8
    vlen: fft_size
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: s8
    output_type: s8
    vlen: fft_size
  states: {}

connections:
- [qtgui_fosphor_display_0, cfg, blocks_message_debug_0, print]
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_fft_0, '0']
- [uhd_rfnoc_fft_0, '0', uhd_rfnoc_fosphor_0, '0']
- [uhd_rfnoc_fosphor_0, '0', uhd_rfnoc_rx_streamer_0_0, '0']
- [uhd_rfnoc_fosphor_0, '1', uhd_rfnoc_rx_streamer_0_0_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0_0, '0', qtgui_fosphor_display_0, '0']
- [uhd_rfnoc_rx_streamer_0_0_0, '0', qtgui_fosphor_display_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-372-gb260520f
