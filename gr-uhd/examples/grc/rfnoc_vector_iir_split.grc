options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    description: The example shows how to use the vector iir filter RFNoC block. It splits a signal from a radio block and shows the filtered and unfiltered output.
    generate_options: qt_gui
    id: rfnoc_vector_iir_split
    output_language: python
    title: 'RFNoC: Vector IIR Example'
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[1,0,1,1]'
    label: Alpha
    type: real
    value: '.9'
  states: {}
- name: beta
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[1,1,1,1]'
    label: Beta
    type: real
    value: '.9'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,0,1,1]'
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,1,1,1]'
    label: Gain (dB)
    type: int
    value: '15'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 153.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=n3xx
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: ':[4,0,1,1]'
    legend: 'False'
    name: Unfiltered Output
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    grid: 'True'
    gui_hint: ':[4,1,1,1]'
    legend: 'False'
    name: FFT Spectrum
    vlen: fft_size
    x_axis_label: Frequency (Hz)
    x_start: freq-samp_rate/2
    x_step: samp_rate/fft_size
    x_units: Hz
    y_axis_label: '|FFT^2|'
    y_units: dB
    ymin: '-90'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: samp_rate
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    fft_direction: FORWARD
    fft_length: fft_size
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    block_args: f"spp={fft_size}"
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    iq_balance0: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
    vlen: fft_size
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_split_stream_0
  id: uhd_rfnoc_split_stream
  parameters:
    num_branches: '2'
    type: sc16
  states: {}
- name: uhd_rfnoc_vector_iir_0
  id: uhd_rfnoc_vector_iir
  parameters:
    alpha: alpha
    beta: beta
    delay: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_split_stream_0, '0']
- [uhd_rfnoc_fft_0, '0', uhd_rfnoc_vector_iir_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_rfnoc_rx_streamer_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_rfnoc_split_stream_0, '0', uhd_rfnoc_rx_streamer_0_0, '0']
- [uhd_rfnoc_split_stream_0, '1', uhd_rfnoc_fft_0, '0']
- [uhd_rfnoc_vector_iir_0, '0', uhd_rfnoc_rx_streamer_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-427-gebdbf1e8
