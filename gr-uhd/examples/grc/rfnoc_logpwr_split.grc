options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    description: The example shows how to use the log power RFNoC block. It splits a signal from a radio block and shows the log power output and signal output
    generate_options: qt_gui
    id: rfnoc_logpwr_split
    output_language: python
    title: 'RFNoC: Log Power Example'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,0,1,1]'
    label: Frequency (Hz)
    type: real
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,1,1,1]'
    label: Gain (dB)
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 153.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=n3xx
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1024'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: ':[4,1,1,1]'
    legend: 'False'
    name: '"Log Power"'
    size: '4096'
    srate: samp_rate
    type: float
    ymax: '60'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: ':[4,0,1,1]'
    legend: 'False'
    name: '"IQ Signal"'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: samp_rate
  states: {}
- name: uhd_rfnoc_logpwr_0
  id: uhd_rfnoc_logpwr
  parameters: {}
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    dc_offset0: 'False'
    frequency0: freq
    gain0: gain
    iq_balance0: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: s16
    output_type: s16
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_split_stream_0
  id: uhd_rfnoc_split_stream
  parameters:
    num_branches: '2'
    type: sc16
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_split_stream_0, '0']
- [uhd_rfnoc_logpwr_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_short_to_float_0, '0']
- [uhd_rfnoc_rx_streamer_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_rfnoc_split_stream_0, '0', uhd_rfnoc_rx_streamer_0_0, '0']
- [uhd_rfnoc_split_stream_0, '1', uhd_rfnoc_logpwr_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-433-g29e5e4f9
