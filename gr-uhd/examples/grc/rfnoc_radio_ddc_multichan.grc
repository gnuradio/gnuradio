options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    comment: "This is a basic downlink setup using RFNoC, \r\nthat is based on the rfnoc_ddc_radio.grc file. \r\nIt transmits two cosine waveforms directly \r\nto the antenna. This example demonstrates \r\nthat you can utilize multiple channels with \r\nvarious blocks.\n\nThis program will not work with all USRP. \nIt depends on the daugtherboards that are \nused. Make sure that the daughterboard\nyou are using support two channels RX."
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rfnoc_radio_ddc_multichannel
    output_language: python
    title: 'RFNoC: Radio -> DDC Multichannel Example'
  states: {}

blocks:
- name: freq0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,0,1,1]'
    label: 'Ch0: Frequency (Hz)'
    type: real
    value: 3e9
  states: {}
- name: freq1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[0,1,1,1]'
    label: 'Ch1: Frequency (Hz)'
    type: raw
    value: 2e9
  states: {}
- name: gain0
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,0,1,1]'
    label: 'Ch0: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: gain1
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[2,1,1,1]'
    label: 'Ch1: Gain (dB)'
    type: int
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: samp_rate0
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: type=x4xx
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate0
    fc: freq0
    fftsize: '1024'
    gui_hint: ':[3,0,1,1]'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate1
    fc: freq1
    fftsize: '1024'
    gui_hint: ':[3,1,1,1]'
    legend: 'False'
    type: complex
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    freq1: '0'
    num_chans: '2'
    output_rate0: samp_rate0
    output_rate1: samp_rate1
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX1
    antenna1: RX1
    bandwidth0: '0'
    bandwidth1: '0'
    dc_offset0: 'False'
    dc_offset1: 'False'
    frequency0: freq0
    frequency1: freq1
    gain0: gain0
    gain1: gain1
    iq_balance0: 'False'
    iq_balance1: 'False'
    num_chans: '2'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    issue_stream_cmd: 'True'
    otw: sc16
    output_type: fc32
  states: {}

connections:
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_rx_streamer_0_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_ddc_0, src_port_id: '1'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '0', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '0'}
- {params: {is_back_edge: 'False'}, snk_blk_id: uhd_rfnoc_ddc_0, snk_port_id: '1', src_blk_id: uhd_rfnoc_rx_radio_0, src_port_id: '1'}
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_rfnoc_rx_streamer_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 2
  grc_version: v3.11.0.0git-950-g72a09243
