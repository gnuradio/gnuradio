options:
  parameters:
    author: Grant Meyerhoff <grant.meyerhoff@ni.com>
    copyright: Copyright 2023 Ettus Research, a National Instruments Brand
    description: This example shows how to use the RFNoC Moving Average block
    generate_options: qt_gui
    id: rfnoc_moving_average
    output_language: python
    title: RFNoC Moving Average Example
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    orient: QtCore.Qt.Orientation.Horizontal
    start: 10e6
    step: 1e6
    stop: 6e9
    value: 1e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '35'
    value: '10'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 153.6e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: uhd_rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"type=n3xx"'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    grid: 'True'
    name: FFT Spectrum
    vlen: fft_size
    x_axis_label: Frequency (Hz)
    x_start: freq-samp_rate/2
    x_step: samp_rate/fft_size
    x_units: Hz
    y_axis_label: '|FFT^2|'
    y_units: dB
    ymin: '-70'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq: '0'
    output_rate: samp_rate
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    fft_direction: FORWARD
    fft_length: fft_size
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_moving_avg_0
  id: uhd_rfnoc_moving_avg
  parameters:
    divisor: '10'
    sum_len: '10'
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    agc: Default
    antenna: RX2
    bandwidth: '0'
    dc_offset: 'False'
    frequency: freq
    gain: gain
    iq_balance: 'False'
    rate: radio_rate
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_fft_0, '0']
- [uhd_rfnoc_fft_0, '0', uhd_rfnoc_moving_avg_0, '0']
- [uhd_rfnoc_moving_avg_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-413-gcbbb7fff
