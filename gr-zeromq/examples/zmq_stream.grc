<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>zmq_stream</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"PUSH/PULL"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"PUB/SUB"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"REQ/REP"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"packet_len"</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5555</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_source</key>
<param><key>id</key><value>zeromq_pull_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_rep_sink</key>
<param><key>id</key><value>zeromq_rep_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5557</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_req_source</key>
<param><key>id</key><value>zeromq_req_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5557</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5555</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>zeromq_pub_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>zeromq_rep_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_req_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
