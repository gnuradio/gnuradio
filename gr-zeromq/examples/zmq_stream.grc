options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: zmq_stream
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,3
    legend: 'False'
    showports: 'True'
    type: float
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 0,1,1,1
    label1: ''
    legend: 'False'
    name: '"PUSH/PULL"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 0,0,1,1
    label1: ''
    legend: 'False'
    name: '"PUB/SUB"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 0,2,1,1
    label1: ''
    legend: 'False'
    name: '"REQ/REP"'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5556
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:5557
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:5557
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', zeromq_push_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [zeromq_pull_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_req_source_0, '0', qtgui_time_sink_x_0_1, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
