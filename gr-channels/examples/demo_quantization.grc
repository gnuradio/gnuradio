options:
  parameters:
    author: mettus
    category: Custom
    generate_options: qt_gui
    id: demo_quantization
    output_language: python
  states: {}

blocks:
- name: bits
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,2,1,1
    label: Bits
    labels: '[''0'', ''1'', ''2'', ''4'', ''6'', ''8'', ''10'', ''12'', ''14'', ''16'']'
    num_opts: '0'
    options: '[0, 1, 2, 4, 6, 8, 10, 12, 14, 16]'
    type: int
    value: '16'
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: BW
    orient: QtCore.Qt.Orientation.Horizontal
    start: samp_rate/100
    step: '100'
    stop: samp_rate/2
    value: samp_rate/2
  states: {}
- name: center
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Center Freq.
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: samp_rate/11.0
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Noise Power
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-150'
    step: '1'
    stop: '0'
    value: '-150'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: sigfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Signal Freq
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '100'
    stop: samp_rate/2
    value: samp_rate*1.0247385/11.0
  states: {}
- name: signal_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Signal Power
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-150'
    step: '1'
    stop: '0'
    value: '-150'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: pow(10.0,noise_amp/20.0)
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: pow(10.0,signal_amp/20.0)
    freq: sigfreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: min(samp_rate/2.0-bw/15.0,center+bw/2.0)
    low_cutoff_freq: max(bw/15.0,center-bw/2.0)
    samp_rate: samp_rate
    type: fir_filter_fff
    width: bw/5.0
    win: window.WIN_HANN
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(2,bits-1)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: channels_quantizer_0
  id: channels_quantizer
  parameters:
    bits: bits
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 3,1,1,2
    name: ''
    showports: 'True'
    type: float
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '1000'
    name: ''
    size: '10240'
    type: float
    update_time: '0.1'
    xmax: '10000'
    xmin: '-10000'
  states: {}

connections:
- [analog_noise_source_x_0, '0', band_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_throttle2_0, '0', channels_quantizer_0, '0']
- [channels_quantizer_0, '0', blocks_multiply_const_vxx_0, '0']
- [channels_quantizer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
