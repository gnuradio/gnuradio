options:
  parameters:
    author: Example
    category: Custom
    description: example flow graph
    generate_options: qt_gui
    id: dial_tone
    output_language: python
    title: Dial Tone
  states: {}

blocks:
- name: ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1, 2
    label: Volume
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '.001'
    stop: '.5'
    value: '.4'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0, 1, 2
    label: Noise Amplitude
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '.001'
    stop: '.2'
    value: '0.005'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '-42'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: '350'
    offset: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: ampl
    freq: '440'
    offset: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx, '1']
- [blocks_add_xx, '0', audio_sink, '0']

metadata:
  file_format: 1
