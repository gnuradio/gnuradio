options:
  parameters:
    generate_options: qt_gui
    id: soapy_rcv2
    output_language: python
    title: SOAPY Receive Test
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: lna
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '50'
    value: '0'
  states: {}
- name: mix
  id: variable_qtgui_range
  parameters:
    label: MIX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: vga
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '50'
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-80'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    ant0: antenna
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: airspy
    lna_gain0: lna
    mix_gain0: mix
    overall_gain0: '0'
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    type: fc32
    vga_gain0: vga
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
