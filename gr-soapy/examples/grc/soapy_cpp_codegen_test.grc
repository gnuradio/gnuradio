options:
  parameters:
    author: GNU Radio Team
    description: Test flowgraph for Soapy SDR C++ code generation
    generate_options: qt_gui
    id: soapy_codegen_test
    output_language: python
    title: Soapy SDR C++ Code Generation Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_4
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_5
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_6
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_sink_7
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_source_2
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_source_3
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: null_source_4
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: soapy_airspyhf_source_0
  id: soapy_airspyhf_source
  parameters:
    center_freq: freq
    samp_rate: '768000'
    type: fc32
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: '0.0'
    center_freq0: freq
    driver: rtlsdr
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    bandwidth0: '0.0'
    center_freq0: freq
    driver: rtlsdr
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    bias: 'False'
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [null_source_0, '0', soapy_limesdr_sink_0, '0']
- [null_source_1, '0', soapy_hackrf_sink_0, '0']
- [null_source_2, '0', soapy_plutosdr_sink_0, '0']
- [null_source_3, '0', soapy_bladerf_sink_0, '0']
- [null_source_4, '0', soapy_custom_sink_0, '0']
- [soapy_airspyhf_source_0, '0', null_sink_5, '0']
- [soapy_bladerf_source_0, '0', null_sink_3, '0']
- [soapy_custom_source_0, '0', null_sink_7, '0']
- [soapy_hackrf_source_0, '0', null_sink_1, '0']
- [soapy_limesdr_source_0, '0', null_sink_0, '0']
- [soapy_plutosdr_source_0, '0', null_sink_2, '0']
- [soapy_rtlsdr_source_0, '0', null_sink_4, '0']
- [soapy_sdrplay_source_0, '0', null_sink_6, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
