options:
  parameters:
    generate_options: qt_gui
    id: soapy_rcv
    output_language: python
    title: SOAPY Receive Test
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '2'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,1,1
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    int_max: '-10'
    int_min: '-80'
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: rtlsdr
    overall_gain0: gain
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    type: fc32
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
