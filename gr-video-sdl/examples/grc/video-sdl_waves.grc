options:
  parameters:
    author: Marcus Müller, Oleg Nikitin
    generate_options: no_gui
    id: waves
    output_language: python
    title: SDL Demo
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: update_rate*periods_per_row*num_rows
    offset: '1'
    phase: '0'
    samp_rate: update_rate*vector_length*num_rows
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**6
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: 0.25/update_rate
    samples_per_second: update_rate*vector_length*num_rows
    type: float
  states: {}
- name: num_rows
  id: parameter
  parameters:
    label: Number of Rows
    short_id: n
    type: intx
    value: '512'
  states: {}
- name: periods_per_row
  id: parameter
  parameters:
    label: Periods per Row
    short_id: p
    type: eng_float
    value: 1-1/255
  states: {}
- name: update_rate
  id: parameter
  parameters:
    label: Update Rate
    short_id: r
    type: intx
    value: '25'
  states: {}
- name: vector_length
  id: parameter
  parameters:
    label: Vector Length
    short_id: l
    type: intx
    value: '512'
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: num_rows
    display_width: vector_length
    fps: '0'
    height: num_rows
    type: short
    width: vector_length
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_short_0, '0', video_sdl_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_float_to_short_0, '0']

metadata:
  file_format: 1
  grc_version: g935569cc9
