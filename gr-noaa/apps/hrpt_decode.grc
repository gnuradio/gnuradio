<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hrpt_decode</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_clock_offset</value></param>
<param><key>value</key><value>100e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/sym_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>decim</value></param>
<param><key>value</key><value>32</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>d</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>label</key><value>pll_alpha</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>label</key><value>clock_alpha</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>file</key><value>input_filename</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>decoder</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>output</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_filename</value></param>
<param><key>label</key><value>input_filename</value></param>
<param><key>value</key><value>frames.hrpt</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>F</value></param>
</block>
<connection><source_block_id>file_source</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
