<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_hrpt_nogui</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_clock_offset</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>os.environ['HOME']+'/.gnuradio/config.conf'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'clock_alpha'</value></param>
<param><key>writeback</key><value>clock_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'gain'</value></param>
<param><key>writeback</key><value>gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1698e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'freq'</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'decim'</value></param>
<param><key>writeback</key><value>decim</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>output_filename</value></param>
<param><key>value</key><value>'frames.dat'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'filename'</value></param>
<param><key>writeback</key><value>output_filename</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'pll_alpha'</value></param>
<param><key>writeback</key><value>pll_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>side</value></param>
<param><key>value</key><value>'A'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'side'</value></param>
<param><key>writeback</key><value>side</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>gr_clock_recovery_mm_xx</key>
<param><key>id</key><value>gr_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>sps/2.0</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>omega_relative_limit</key><value>max_clock_offset</value></param>
</block>
<block>
<key>gr_moving_average_xx</key>
<param><key>id</key><value>gr_moving_average_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>hs</value></param>
<param><key>scale</key><value>1.0/hs</value></param>
<param><key>max_iter</key><value>4000</value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>noaa_hrpt_deframer</key>
<param><key>id</key><value>deframer</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>frame_sink</value></param>
<param><key>file</key><value>output_filename</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>noaa_hrpt_bit_sync</key>
<param><key>id</key><value>noaa_hrpt_bit_sync_0</value></param>
</block>
<block>
<key>gr_binary_slicer_fb</key>
<param><key>id</key><value>gr_binary_slicer_fb_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>decoder</value></param>
</block>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>gr_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_moving_average_xx_0</source_block_id><sink_block_id>gr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>noaa_hrpt_bit_sync_0</source_block_id><sink_block_id>deframer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_binary_slicer_fb_0</source_block_id><sink_block_id>noaa_hrpt_bit_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gr_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>frame_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
