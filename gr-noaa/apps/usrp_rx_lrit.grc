<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_lrit</value></param>
<param><key>title</key><value>USRP LRIT Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>293e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/symbol_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>os.environ['HOME']+'/.gnuradio/config.conf'</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>saved_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_freq</value></param>
<param><key>value</key><value>1691e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'freq'</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'offset'</value></param>
<param><key>writeback</key><value>offset</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset</value></param>
<param><key>label</key><value>Offset</value></param>
<param><key>value</key><value>saved_offset</value></param>
<param><key>min</key><value>-50e3</value></param>
<param><key>max</key><value>50e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>costas_alpha</value></param>
<param><key>label</key><value>Costas Alpha</value></param>
<param><key>value</key><value>saved_costas_alpha</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>value</key><value>saved_gain_mu</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 2, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain</value></param>
<param><key>value</key><value>33</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'gain'</value></param>
<param><key>writeback</key><value>gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_decim</value></param>
<param><key>value</key><value>160</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'decim'</value></param>
<param><key>writeback</key><value>decim</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decim</value></param>
<param><key>value</key><value>saved_decim</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_costas_alpha</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'costas_alpha'</value></param>
<param><key>writeback</key><value>costas_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain_mu</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'gain_mu'</value></param>
<param><key>writeback</key><value>gain_mu</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>side</value></param>
<param><key>value</key><value>'A'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_lrit'</value></param>
<param><key>option</key><value>'side'</value></param>
<param><key>writeback</key><value>side</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>gr_agc_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0/32767.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>rx_waveform</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RX Waveform</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>20.0/sample_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>rx_spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RX Spectrum</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
<param><key>alpha</key><value>0.25</value></param>
<param><key>ntaps</key><value>int(11*sample_rate/symbol_rate)</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>rrc_waveform</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RRC Waveform</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>20.0/sample_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>rrc_spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RRC Spectrum</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>baseband_freq</key><value>freq+offset</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-15</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>gr_costas_loop_cc</key>
<param><key>id</key><value>costas</value></param>
<param><key>alpha</key><value>costas_alpha</value></param>
<param><key>beta</key><value>(costas_alpha**2.0)/4.0</value></param>
<param><key>max_freq</key><value>50e-6*sps</value></param>
<param><key>min_freq</key><value>-50e-6*sps</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>costas_spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>PLL Spectrum</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>baseband_freq</key><value>freq+offset</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-15</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 2</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>mm_spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Bit Sync Spectrum</value></param>
<param><key>samp_rate</key><value>symbol_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-15</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 3</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>costas_waveform</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>PLL Waveform</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>20.0/sample_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 2</value></param>
</block>
<block>
<key>gr_clock_recovery_mm_xx</key>
<param><key>id</key><value>mm_sync</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>gain_omega</key><value>(gain_mu**2)/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>omega_relative_limit</key><value>50e-6*sps</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>mm_const</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Constellation</value></param>
<param><key>samp_rate</key><value>symbol_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>20.0/symbol_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 3</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>displays</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['USRP RX','RRC','PLL','Const']</value></param>
<param><key>grid_pos</key><value>2, 0, 1, 3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>saved_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>115</value></param>
<param><key>num_steps</key><value>115</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>lrit.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq+offset</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source_x_0</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source_x_0</source_block_id><sink_block_id>rx_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>rx_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source_x_0</source_block_id><sink_block_id>rx_waveform</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>rx_waveform</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>rrc_waveform</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>rrc_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>costas</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>costas</source_block_id><sink_block_id>costas_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>costas</source_block_id><sink_block_id>costas_waveform</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>costas</source_block_id><sink_block_id>mm_sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mm_sync</source_block_id><sink_block_id>mm_spectrum</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mm_sync</source_block_id><sink_block_id>mm_const</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
