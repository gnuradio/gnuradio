<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_lrit</value></param>
<param><key>title</key><value>USRP LRIT Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>293e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate/symbol_rate</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decim</value></param>
<param><key>value</key><value>saved_decim</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waveform</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>t_scale</key><value>20.0/samp_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>gr_agc_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0/32767.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>ntaps</key><value>50</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>side</key><value>B</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.4</value></param>
<param><key>t_scale</key><value>20.0/samp_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>gr_probe_mpsk_snr_c</key>
<param><key>id</key><value>gr_probe_mpsk_snr_c_0</value></param>
<param><key>type</key><value>snr</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>probe_rate</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>SNR</value></param>
<param><key>units</key><value>dB</value></param>
<param><key>samp_rate</key><value>10</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>30</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>1</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>10</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>2, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>gr_mpsk_receiver_cc</key>
<param><key>id</key><value>gr_mpsk_receiver_cc_0</value></param>
<param><key>M</key><value>2</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>alpha</key><value>costas_alpha</value></param>
<param><key>beta</key><value>costas_alpha*costas_alpha/4.0</value></param>
<param><key>fmin</key><value>-0.05</value></param>
<param><key>fmax</key><value>0.05</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>gain_mu</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>gain_omega</key><value>gain_mu*gain_mu/4.0</value></param>
<param><key>omega_relative_limit</key><value>0.05</value></param>
</block>
<block>
<key>gr_complex_to_real</key>
<param><key>id</key><value>gr_complex_to_real_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_0</value></param>
</block>
<block>
<key>gr_binary_slicer_fb</key>
<param><key>id</key><value>gr_binary_slicer_fb_0</value></param>
</block>
<block>
<key>gr_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>48.0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_char</key>
<param><key>id</key><value>gr_float_to_char_0</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>bits.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>lrit.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>displays</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['USRP RX', 'Costas Output']</value></param>
<param><key>grid_pos</key><value>2, 0, 1, 3</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_decim</value></param>
<param><key>value</key><value>160</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>decim</value></param>
<param><key>writeback</key><value>decim</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>saved_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>115</value></param>
<param><key>num_steps</key><value>115</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain</value></param>
<param><key>value</key><value>33</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>writeback</key><value>gain</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>saved_freq</value></param>
<param><key>min</key><value>135e6</value></param>
<param><key>max</key><value>139e6</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_freq</value></param>
<param><key>value</key><value>137e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>costas_alpha</value></param>
<param><key>label</key><value>Costas Alpha</value></param>
<param><key>value</key><value>saved_costas_alpha</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_costas_alpha</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>costas_alpha</value></param>
<param><key>writeback</key><value>costas_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain_mu</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>gain_mu</value></param>
<param><key>writeback</key><value>gain_mu</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_mu</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>value</key><value>saved_gain_mu</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>"usrp_rx_lrit.cfg"</value></param>
</block>
<connection><source_block_id>usrp_simple_source_x_0</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>gr_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_probe_mpsk_snr_c_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_mpsk_receiver_cc_0</source_block_id><sink_block_id>gr_probe_mpsk_snr_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>gr_mpsk_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_mpsk_receiver_cc_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_agc_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_mpsk_receiver_cc_0</source_block_id><sink_block_id>gr_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_real_0</source_block_id><sink_block_id>gr_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_binary_slicer_fb_0</source_block_id><sink_block_id>gr_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>gr_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_0</source_block_id><sink_block_id>gr_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_float_to_char_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
