<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_hrpt</value></param>
<param><key>title</key><value>USRP HRPT Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>saved_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>saved_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>label</key><value>PLL Alpha</value></param>
<param><key>value</key><value>saved_pll_alpha</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>side_text</value></param>
<param><key>label</key><value>USRP Side</value></param>
<param><key>value</key><value>side</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>decim_text</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>decim</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>os.environ['HOME']+'/.gnuradio/config.conf'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_freq</value></param>
<param><key>value</key><value>1698e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'freq'</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'gain'</value></param>
<param><key>writeback</key><value>gain</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>label</key><value>Clock Alpha</value></param>
<param><key>value</key><value>saved_clock_alpha</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 3, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>side</value></param>
<param><key>value</key><value>'A'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'side'</value></param>
<param><key>writeback</key><value>side</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>displays</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Spectrum','Demod']</value></param>
<param><key>grid_pos</key><value>2,0,1,4</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>frame_sink</value></param>
<param><key>file</key><value>output_filename</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>demod_scope</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Post-Demod</value></param>
<param><key>samp_rate</key><value>sym_rate*2.0</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>10.0/sym_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>gr_clock_recovery_mm_xx</key>
<param><key>id</key><value>gr_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>sps/2.0</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>omega_relative_limit</key><value>max_clock_offset</value></param>
</block>
<block>
<key>gr_moving_average_xx</key>
<param><key>id</key><value>gr_moving_average_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>hs</value></param>
<param><key>scale</key><value>1.0/hs</value></param>
<param><key>max_iter</key><value>4000</value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>rx_fft</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RX Spectrum</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>8</value></param>
<param><key>ref_level</key><value>-5</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>640, 360</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
</block>
<block>
<key>gr_binary_slicer_fb</key>
<param><key>id</key><value>gr_binary_slicer_fb_0</value></param>
</block>
<block>
<key>noaa_hrpt_deframer</key>
<param><key>id</key><value>deframer</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>32</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'decim'</value></param>
<param><key>writeback</key><value>decim</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_pll_alpha</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'pll_alpha'</value></param>
<param><key>writeback</key><value>pll_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_clock_alpha</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'clock_alpha'</value></param>
<param><key>writeback</key><value>clock_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>output_filename</value></param>
<param><key>value</key><value>'frames.hrpt'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp_rx_hrpt'</value></param>
<param><key>option</key><value>'filename'</value></param>
<param><key>writeback</key><value>output_filename</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>decoder</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>output</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_clock_offset</value></param>
<param><key>value</key><value>100e-6</value></param>
</block>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gr_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>frame_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_clock_recovery_mm_xx_0</source_block_id><sink_block_id>demod_scope</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_moving_average_xx_0</source_block_id><sink_block_id>gr_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>gr_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>rx_fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_binary_slicer_fb_0</source_block_id><sink_block_id>deframer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
