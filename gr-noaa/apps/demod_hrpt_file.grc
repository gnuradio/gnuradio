<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>max_sync_offset</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>Filename</value></param>
<param><key>value</key><value>usrp.dat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>F</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output</value></param>
<param><key>label</key><value>Output</value></param>
<param><key>value</key><value>frames.dat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>f2c</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>samples_sink</value></param>
<param><key>stream_id</key><value>samples</value></param>
</block>
<block>
<key>noaa_hrpt_sync_fb</key>
<param><key>id</key><value>sync</value></param>
<param><key>alpha</key><value>sync_alpha</value></param>
<param><key>beta</key><value>sync_alpha**2/4.0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>max_offset</key><value>max_sync_offset</value></param>
</block>
<block>
<key>noaa_hrpt_deframer</key>
<param><key>id</key><value>deframer</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>file_sink</value></param>
<param><key>file</key><value>output</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>decoder</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>deinterleave</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>d</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>samples_source</value></param>
<param><key>stream_id</key><value>samples</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>s2f</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mf_taps</value></param>
<param><key>value</key><value>[-0.5/hs,]*hs+[0.5/hs,]*hs</value></param>
</block>
<block>
<key>gr_fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>mf_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>demod_hrpt_file</value></param>
<param><key>title</key><value>USRP HRPT Receiver</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<connection><source_block_id>deframer</source_block_id><sink_block_id>file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync</source_block_id><sink_block_id>deframer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deinterleave</source_block_id><sink_block_id>f2c</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>deinterleave</source_block_id><sink_block_id>f2c</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>f2c</source_block_id><sink_block_id>samples_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>samples_source</source_block_id><sink_block_id>gr_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s2f</source_block_id><sink_block_id>deinterleave</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>file_source</source_block_id><sink_block_id>s2f</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
