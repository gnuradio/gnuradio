<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>sample_rate/sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>64e6/decim</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>saved_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>saved_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>label</key><value>PLL Alpha</value></param>
<param><key>value</key><value>saved_pll_alpha</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sync_alpha</value></param>
<param><key>label</key><value>SYNC Alpha</value></param>
<param><key>value</key><value>saved_sync_alpha</value></param>
<param><key>min</key><value>0.0</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 3, 1, 1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>side_text</value></param>
<param><key>label</key><value>USRP Side</value></param>
<param><key>value</key><value>side</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>side</value></param>
<param><key>value</key><value>'A'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp'</value></param>
<param><key>option</key><value>'side'</value></param>
<param><key>writeback</key><value>side</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp'</value></param>
<param><key>option</key><value>'decim'</value></param>
<param><key>writeback</key><value>decim</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_freq</value></param>
<param><key>value</key><value>1698e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp'</value></param>
<param><key>option</key><value>'freq'</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'usrp'</value></param>
<param><key>option</key><value>'gain'</value></param>
<param><key>writeback</key><value>gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_pll_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'demod'</value></param>
<param><key>option</key><value>'pll_alpha'</value></param>
<param><key>writeback</key><value>pll_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_sync_alpha</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'demod'</value></param>
<param><key>option</key><value>'sync_alpha'</value></param>
<param><key>writeback</key><value>sync_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>output_filename</value></param>
<param><key>value</key><value>'frames.dat'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>'output'</value></param>
<param><key>option</key><value>'filename'</value></param>
<param><key>writeback</key><value>output_filename</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>decim_text</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>decim</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_sync_offset</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>'usrp_rx_hrpt.cfg'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>noaa_hrpt_sync_fb</key>
<param><key>id</key><value>sync</value></param>
<param><key>alpha</key><value>sync_alpha</value></param>
<param><key>beta</key><value>sync_alpha**2/4.0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>max_offset</key><value>max_sync_offset</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>frame_sink</value></param>
<param><key>file</key><value>output_filename</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>noaa_hrpt_deframer</key>
<param><key>id</key><value>deframer</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>decoder</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>pll_scope</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Demod Waveform</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>t_scale</key><value>20.0/sample_rate</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>2,0,1,4</value></param>
</block>
<block>
<key>gr_agc_xx</key>
<param><key>id</key><value>agc</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>gr_fir_filter_xxx</key>
<param><key>id</key><value>gr_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>mf_taps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mf_taps</value></param>
<param><key>value</key><value>[-0.5/hs,]*hs+[0.5/hs,]*hs</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>'usrp.dat'</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>s2f</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>sample_stream</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>samples</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value>RXA</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>samples</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>usrp_rx_hrpt2</value></param>
<param><key>title</key><value>USRP HRPT Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<connection><source_block_id>gr_fir_filter_xxx_0</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc</source_block_id><sink_block_id>gr_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>decoder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>pll_scope</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync</source_block_id><sink_block_id>deframer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>deframer</source_block_id><sink_block_id>frame_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>agc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>file_source</source_block_id><sink_block_id>s2f</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s2f</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>sample_stream</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
