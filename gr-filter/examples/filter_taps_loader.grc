options:
  parameters:
    generate_options: qt_gui
    id: filter_taps_loader
    output_language: python
    title: Complex Taps Loaded From File
  states: {}

blocks:
- name: bp_taps
  id: variable_file_filter_taps
  parameters:
    file: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/filter/filter_taps_example_complex_bandpass_taps"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import subprocess
  states: {}
- name: lp_filter
  id: fir_filter_xxx
  parameters:
    comment: Low-pass filter
    decim: '1'
    taps: bp_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.9'
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    label1: Low-pass
    showports: 'True'
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', lp_filter, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [lp_filter, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
