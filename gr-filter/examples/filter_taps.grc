<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Please coy filter_taps_example_complex_bandpass_taps to /tmp/ or change the file path.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Example demonstrating capabilities of different convenience blocks for filters.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bp_high</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bp_low</value></param>
<param><key>value</key><value>6000</value></param>
</block>
<block>
<key>variable_band_pass_filter_taps</key>
<param><key>id</key><value>bp_taps</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>high_cutoff_freq</key><value>bp_high</value></param>
<param><key>low_cutoff_freq</key><value>bp_low</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>taps_real</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_band_reject_filter_taps</key>
<param><key>id</key><value>br_taps</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>high_cutoff_freq</key><value>bp_high</value></param>
<param><key>low_cutoff_freq</key><value>bp_low</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_high</value></param>
<param><key>value</key><value>14000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_low</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable_file_filter_taps</key>
<param><key>id</key><value>file_taps</value></param>
<param><key>file</key><value>/tmp/filter_taps_example_complex_bandpass_taps</value></param>
</block>
<block>
<key>variable_high_pass_filter_taps</key>
<param><key>id</key><value>hp_taps</value></param>
<param><key>cutoff_freq</key><value>cutoff_low</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_taps</value></param>
<param><key>value</key><value>len(lp_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lp_taps</value></param>
<param><key>cutoff_freq</key><value>cutoff_high</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate*100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>bp_filter</value></param>
<param><key>comment</key><value>Band-pass filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>bp_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>br_filter</value></param>
<param><key>comment</key><value>Band-reject filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>br_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>file_taps_filter</value></param>
<param><key>comment</key><value>File taps filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>file_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>hp_filter</value></param>
<param><key>comment</key><value>High-pass filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>hp_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>lp_filter</value></param>
<param><key>comment</key><value>Low-pass filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>lp_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.9</value></param>
<param><key>label1</key><value>Low-pass</value></param>
<param><key>alpha2</key><value>0.9</value></param>
<param><key>label2</key><value>High-pass</value></param>
<param><key>alpha3</key><value>0.9</value></param>
<param><key>label3</key><value>Band-pass</value></param>
<param><key>alpha4</key><value>0.9</value></param>
<param><key>color4</key><value>"cyan"</value></param>
<param><key>label4</key><value>Band-reject</value></param>
<param><key>alpha5</key><value>0.9</value></param>
<param><key>color5</key><value>"magenta"</value></param>
<param><key>label5</key><value>RRC</value></param>
<param><key>color6</key><value>"yellow"</value></param>
<param><key>label6</key><value>File</value></param>
<param><key>nconnections</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>rrc_filter</value></param>
<param><key>comment</key><value>RRC filter</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>bp_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>br_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>file_taps_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>hp_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lp_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rrc_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bp_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>br_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>file_taps_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>hp_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lp_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rrc_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
</flow_graph>
