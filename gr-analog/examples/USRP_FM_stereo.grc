options:
  parameters:
    author: Barry Duggan
    generate_options: qt_gui
    id: USRP_FM_stereo
    output_language: python
    title: Broadcast FM stereo
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '200000'
    stop: '108000000'
    value: '102100000'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.2'
    widget: slider
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: audio_decim
    deemph_tau: '75e-6'
    quad_rate: (int)(samp_rate/rf_decim)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: rf_decim
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: center_freq
    gain0: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(center_freq, 180000)
    dev_addr: ''
    dev_args: '""'
    gain0: rf_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '1']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_pll_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [soapy_custom_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
