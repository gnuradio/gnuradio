options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: fm_deviation_hz
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: in_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: resamp_rate
  id: variable
  parameters:
    value: audio_rate/in_rate
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: in_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: in_rate/(2*math.pi*fm_deviation_hz)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: dummy.dat
    repeat: 'True'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: resamp_rate
    taps: firdes.low_pass_2(volume*nfilts, nfilts*in_rate, 15e3, 1e3, 60, fft.window.WIN_KAISER)
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: ''
    type: float
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: in_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    name: ''
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    name: ''
    type: float
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    name: ''
    size: '1024'
    srate: in_rate
    type: complex
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: ''
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,1
    name: ''
    size: '1024'
    srate: audio_rate
    type: float
  states: {}

connections:
- [analog_fm_deemph_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', audio_sink_0, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [pfb_arb_resampler_xxx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']

metadata:
  file_format: 1
