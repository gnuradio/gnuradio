options:
  parameters:
    author: Travis Collins <travis.collins@analog.com>
    copyright: Analog Devices, Inc.
    generate_options: qt_gui
    id: attribute_sink_source
    output_language: python
    title: Attribute Sink Source Example
  states: {}

blocks:
- name: rf_bandwidth_range
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '200000'
    step: '100000'
    stop: '1000000'
    value: '300000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''ip:192.168.2.1'''
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    required_enable: 'False'
    uri: uri
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: hardwaregain
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1024'
    type: '1'
    update_interval_ms: '1'
    uri: uri
  states: {}
- name: iio_attr_source_1
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: rf_bandwidth
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1024'
    type: '1'
    update_interval_ms: '1'
    uri: uri
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: rf_bandwidth
    update_interval_ms: '1000'
    value: str(rf_bandwidth_range)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    marker1: '1'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    marker1: '1'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [iio_attr_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_attr_source_1, '0', qtgui_time_sink_x_1, '0']
- [iio_attr_updater_0, out, blocks_message_debug_0, print]
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]

metadata:
  file_format: 1
