options:
  parameters:
    author: Travis Collins <travis.collins@analog.com>
    copyright: Analog Devices, Inc.
    generate_options: qt_gui
    id: cyclic_sine_pluto
    output_language: python
    title: 'Pluto Example: Cyclic-Sine'
  states: {}

blocks:
- name: RF
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '4'
    value: '1'
  states: {}
- name: Station
  id: variable
  parameters:
    value: '105900000'
  states: {}
- name: audiodecimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audiorate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channeldecimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audiorate*audiodecimation*channeldecimation
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''ip:192.168.2.1'''
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audiodecimation
    quad_rate: audiorate*audiodecimation
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audiorate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audiorate*audiodecimation
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/tcollins/Downloads/audiocheck.net_hdsweep_1Hz_48000Hz_-3dBFS_30s.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30.0'
    auto_filter: 'True'
    bandwidth: audiorate*audiodecimation*channeldecimation
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: audiorate*audiodecimation*channeldecimation
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: audiorate*audiodecimation*channeldecimation
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''slow_attack'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: audiorate*audiodecimation*channeldecimation
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audiorate*audiodecimation*channeldecimation
    fbw: '0.2'
    interp: audiorate*audiodecimation
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: audiorate*audiodecimation
    fbw: '0.2'
    interp: audiorate*audiodecimation*channeldecimation
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_1, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
