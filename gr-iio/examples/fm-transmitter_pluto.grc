options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: fm_station
  id: variable
  parameters:
    value: '98100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate / 8)
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: wav_file
    nchan: '2'
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    fpass: samp_rate/4
    frequency: fm_station
    fstop: samp_rate/3
    samplerate: samp_rate
  states: {}
- name: interpolation
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(8 / interpolation)
    taps: ''
    type: ccc
  states: {}
- name: wav_file
  id: parameter
  parameters:
    label: WAV File
    value: /home/paul/Epoq.wav
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
