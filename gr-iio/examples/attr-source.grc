<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>attr_source_example</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Attribute Source Example</value></param>
</block>
<block>
<key>iio_attr_source</key>
<param><key>id</key><value>iio_attr_source_0</value></param>
<param><key>attribute</key><value>"adi,gc-lmt-overload-high-thresh"</value></param>
<param><key>attr_type</key><value>2</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>type</key><value>1</value></param>
<param><key>device</key><value>"ad9361-phy"</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>samples_per_update</key><value>32</value></param>
<param><key>update_interval_ms</key><value>1</value></param>
<param><key>uri</key><value>"ip:192.168.2.1"</value></param>
</block>
<block>
<key>iio_attr_source</key>
<param><key>id</key><value>iio_attr_source_0_0</value></param>
<param><key>attribute</key><value>"rssi"</value></param>
<param><key>attr_type</key><value>0</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>type</key><value>1</value></param>
<param><key>device</key><value>"ad9361-phy"</value></param>
<param><key>output</key><value>False</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>samples_per_update</key><value>32</value></param>
<param><key>update_interval_ms</key><value>1</value></param>
<param><key>uri</key><value>"ip:192.168.2.1"</value></param>
</block>
<block>
<key>iio_attr_source</key>
<param><key>id</key><value>iio_attr_source_0_0_0</value></param>
<param><key>attribute</key><value>"hardwaregain"</value></param>
<param><key>attr_type</key><value>0</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>type</key><value>1</value></param>
<param><key>device</key><value>"ad9361-phy"</value></param>
<param><key>output</key><value>False</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>samples_per_update</key><value>32</value></param>
<param><key>update_interval_ms</key><value>1</value></param>
<param><key>uri</key><value>"ip:192.168.2.1"</value></param>
</block>
<block>
<key>iio_attr_source</key>
<param><key>id</key><value>iio_attr_source_0_0_0_0</value></param>
<param><key>attribute</key><value>"xo_correction"</value></param>
<param><key>attr_type</key><value>1</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>type</key><value>1</value></param>
<param><key>device</key><value>"ad9361-phy"</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>samples_per_update</key><value>32</value></param>
<param><key>update_interval_ms</key><value>1</value></param>
<param><key>uri</key><value>"ip:192.168.2.1"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>iio_attr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_source_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_source_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
