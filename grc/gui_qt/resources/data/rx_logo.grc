options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rx_logo
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: N
  id: parameter
  parameters:
    type: intx
    value: '512'
  states: {}
- name: ampl
  id: parameter
  parameters:
    label: ampl
    type: eng_float
    value: '0.6'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: N
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: N
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: fancy_logo.dat
    repeat: 'False'
    type: byte
    vlen: N
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl/math.sqrt(N)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.linspace(1.8,0.8,N//2).tolist() + np.linspace(0.8,1.8,N//2).tolist()
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
    vlen: N
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: nrepeat
    type: byte
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: byte
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: np.zeros(N)
    vlen: '512'
  states: {}
- name: cp_len
  id: parameter
  parameters:
    type: long
    value: '64'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: N
    rolloff: '32'
    tagname: '""'
  states: {}
- name: fft_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: freq
  id: parameter
  parameters:
    short_id: f
    type: eng_float
    value: 610e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: nrepeat
  id: parameter
  parameters:
    type: long
    value: '480'
  states: {}
- name: txGain
  id: parameter
  parameters:
    type: eng_float
    value: '24'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    gain0: txGain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_map_bb_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_1, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_repeat_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', fft_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_float_to_complex_0, '1']
- [digital_map_bb_0, '0', blocks_stream_to_vector_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_0, '0', digital_ofdm_cyclic_prefixer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
