<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>USRP2 FFT</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>FFT of Spectrum</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>usrp2_source_xxxx</key>
<param><key>id</key><value>usrp2_source_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value></value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>auto_tr</key><value></value></param>
<param><key>rx_ant</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>100e6/decim</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>12</value></param>
<param><key>ref_level</key><value>20</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100e6</value></param>
<param><key>max</key><value>100e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>slider_length</key><value>200</value></param>
<param><key>slider_type</key><value>horizontal</value></param>
</block>
<connection><source_block_id>usrp2_source_xxxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
