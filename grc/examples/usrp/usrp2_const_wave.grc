<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>USRP2 Const Wave</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>Carrier with constant amplitude</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>value</key><value>15e6</value></param>
<param><key>min</key><value>10e6</value></param>
<param><key>max</key><value>20e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>slider_length</key><value>200</value></param>
<param><key>slider_type</key><value>horizontal</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>0</value></param>
<param><key>waveform</key><value>gr.GR_CONST_WAVE</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>amp</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>usrp2_sink_xxxx</key>
<param><key>id</key><value>usrp2_sink_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value></value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>interpolation</key><value>101</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>auto_tr</key><value></value></param>
<param><key>tx_enb</key><value></value></param>
</block>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>usrp2_sink_xxxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
