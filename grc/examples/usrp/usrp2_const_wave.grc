<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>ampl</value></param>
</block>
<block>
<key>usrp2_sink_xxxx</key>
<param><key>id</key><value>usrp2_sink_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value></value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>interpolation</key><value>interp</value></param>
<param><key>frequency</key><value>tun_freq</value></param>
<param><key>gain</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>label</key><value>USRP2 Freq (Hz)</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>min</key><value>2.4e9</value></param>
<param><key>max</key><value>2.5e9</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>slider_length</key><value>200</value></param>
<param><key>slider_type</key><value>horizontal</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>Amplitude</value></param>
<param><key>value</key><value>.1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>slider_length</key><value>200</value></param>
<param><key>slider_type</key><value>horizontal</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>usrp2_const_wave</value></param>
<param><key>title</key><value>USRP2 Constant Wave</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>Tune USRP2</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>usrp2_sink_xxxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
