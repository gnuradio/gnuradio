options:
  parameters:
    generate_options: qt_gui
    id: epy_block_io_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          # Note: the vlen defaults to 1
          def __init__(self, vlen=1):
              gr.sync_block.__init__(
                  self,
                  name='Test Vector IO extraction',
                  in_sig=[(np.complex64, vlen)],
                  out_sig=[(np.complex64, vlen)]
              )

          def work(self, input_items, output_items):
              output_items[0][:][:] = input_items[0][:][:]
              return len(output_items[0])
    vlen: '64'
  states: {}

connections:
- [blocks_null_source_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
