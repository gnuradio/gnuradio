<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>qt_samp_rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>start</key><value>200000</value></param>
<param><key>stop</key><value>5000000</value></param>
<param><key>step</key><value>200000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>20000000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.11.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>qt_samp_rate</value></param>
<param><key>center_freq0</key><value>98.9e6</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_file_meta_sink</key>
<param><key>id</key><value>gr_file_meta_sink_0</value></param>
<param><key>file</key><value>/tmp/metadat_file.out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>file_metadata_sink</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
