<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>10*[0,1,2,3,4,5,6,7,8,9]</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>10</value></param>
</block>
<block>
<key>gr_file_meta_sink</key>
<param><key>id</key><value>gr_file_meta_sink_0</value></param>
<param><key>file</key><value>/tmp/metadat_file.out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>vlen</key><value>10</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>extra_dict</key><value></value></param>
<param><key>detached</key><value>False</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>file_metadata_vector_sink</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>10010000</value></param>
<param><key>vlen</key><value>10</value></param>
</block>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>gr_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
