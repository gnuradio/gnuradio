options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: fm_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fm_deviation_hz
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: '90500000'
  states: {}
- name: in_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    fs: '400000'
    impl: cpu
    showports: 'False'
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_0
  id: analog_quadrature_demod
  parameters:
    gain: in_rate/(2*math.pi*fm_deviation_hz)
    impl: cpu
    showports: 'False'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_0
  id: qtgui_time_sink
  parameters:
    T: float
    impl: cpu
    name: '"hello"'
    nconnections: '1'
    samp_rate: samp_rate
    showports: 'False'
    size: '10240'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    T: complex
    center_freq: freq
    impl: cpu
    samp_rate: samp_rate
    showports: 'False'
  states: {state: disabled}

connections:
- [analog_fm_deemph_0, '0', qtgui_time_sink_0, '0']
- [analog_quadrature_demod_0, '0', analog_fm_deemph_0, '0']
- [blocks_null_source_0, '0', analog_quadrature_demod_0, '0']
- [soapy_hackrf_source_0, '0', analog_quadrature_demod_0, '0']

metadata:
  file_format: 1
