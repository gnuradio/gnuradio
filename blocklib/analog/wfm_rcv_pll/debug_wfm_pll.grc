options:
  parameters:
    author: josh
    generate_options: no_gui
    id: debug_wfm_pll
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: audio_filter_coeffs
  id: variable
  parameters:
    value: firdes.low_pass(1, demod_rate, 15000, 1500, window.HAMMING, 6.76)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: demod_rate / audio_decim
  states: {}
- name: deemph_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '90500000'
  states: {}
- name: pilot_carrier_filter_coeffs
  id: variable
  parameters:
    value: firdes.complex_band_pass( 1.0, demod_rate, 18980, 19020, 1500, window.HAMMING, 6.76)
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_delay
  id: variable
  parameters:
    value: (len( pilot_carrier_filter_coeffs) - 1) // 2 + (len(stereo_carrier_filter_coeffs) - 1) // 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: stereo_carrier_filter_coeffs
  id: variable
  parameters:
    value: firdes.band_pass( -2.0, demod_rate, 37600, 38400, 400, window.HAMMING, 6.76)
  states: {}
- name: analog_left_fm_deemph
  id: analog_fm_deemph
  parameters:
    fs: audio_rate
    impl: cpu
    showports: 'False'
    tau: '75e-6'
  states: {}
- name: analog_noise_source_0
  id: analog_noise_source
  parameters:
    T: float
    amplitude: '1.0'
    impl: cpu
    seed: '0'
    showports: 'False'
    type: analog.noise_t.UNIFORM
  states: {state: disabled}
- name: analog_pll_refout_0
  id: analog_pll_refout
  parameters:
    impl: cpu
    loop_bw: '0.001'
    max_freq: 2 * pmath.pi * 19200 / demod_rate
    min_freq: 2 * pmath.pi * 18800 / demod_rate
    showports: 'False'
  states: {}
- name: analog_quadrature_demod_0
  id: analog_quadrature_demod
  parameters:
    gain: demod_rate / (2 * pmath.pi * deviation)
    impl: cpu
    showports: 'False'
  states: {}
- name: analog_right_fm_deemph
  id: analog_fm_deemph
  parameters:
    fs: audio_rate
    impl: cpu
    showports: 'False'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_0
  id: analog_sig_source
  parameters:
    T: float
    ampl: '1.0'
    frequency: '1000'
    impl: cpu
    offset: '0'
    phase: '0'
    sampling_freq: demod_rate
    showports: 'False'
    waveform: analog.waveform_t.COS
  states: {state: disabled}
- name: audio_alsa_sink_0
  id: audio_alsa_sink
  parameters:
    device_name: '"pulse"'
    impl: cpu
    num_inputs: '2'
    ok_to_block: 'True'
    sampling_rate: int(audio_rate)
    showports: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: blocks_pilot_multiply
  id: math_multiply
  parameters:
    T: complex
    impl: cpu
    num_inputs: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: blocks_stereo_multiply
  id: math_multiply
  parameters:
    T: float
    impl: cpu
    num_inputs: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: fileio_file_sink_0
  id: fileio_file_sink
  parameters:
    append: 'False'
    filename: /tmp/pll_in.dat
    impl: cpu
    itemsize: '0'
    showports: 'False'
  states: {state: disabled}
- name: fileio_file_source_0
  id: fileio_file_source
  parameters:
    filename: /tmp/fm_in.dat
    impl: cpu
    itemsize: '0'
    len: '0'
    offset: '0'
    repeat: 'False'
    showports: 'False'
  states: {state: disabled}
- name: filter_fft_filter_0
  id: filter_fft_filter
  parameters:
    decimation: rf_decim
    impl: cpu
    nthreads: '0'
    samp_delay: '0'
    showports: 'False'
    taps: firdes.low_pass(1.0, samp_rate, 90000, 20000)
    type_inst: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.kernel.filter import firdes
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.kernel.fft import window
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import math as pmath
  states: {}
- name: math_add_0
  id: math_add
  parameters:
    T: float
    impl: cpu
    nports: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_complex_to_imag_0
  id: math_complex_to_imag
  parameters:
    impl: cpu
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_multiply_const_0
  id: math_multiply_const
  parameters:
    T: float
    impl: cpu
    k: '0.2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_multiply_const_0_0
  id: math_multiply_const
  parameters:
    T: float
    impl: cpu
    k: '0.2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_sub_0
  id: math_sub
  parameters:
    T: float
    impl: cpu
    nports: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: mono_audio_lpf
  id: filter_fft_filter
  parameters:
    decimation: audio_decim
    impl: cpu
    nthreads: '0'
    samp_delay: '0'
    showports: 'False'
    taps: audio_filter_coeffs
    type_inst: fff
  states: {}
- name: pilot_carrier_bpf
  id: filter_fir_filter
  parameters:
    decimation: '1'
    impl: cpu
    showports: 'False'
    taps: pilot_carrier_filter_coeffs
    type_inst: fcc
  states: {}
- name: pyqtgraph_pg_time_sink_0
  id: pyqtgraph_pg_time_sink
  parameters:
    T: float
    dock_position: top
    dock_relative_to: ''
    impl: numpy
    nports: '1'
    samp_rate: samp_rate
    showports: 'False'
    size: '1024'
    title: None
    ylabel: Amplitude
  states: {state: disabled}
- name: pyqtgraph_pg_time_sink_0_0
  id: pyqtgraph_pg_time_sink
  parameters:
    T: float
    dock_position: top
    dock_relative_to: ''
    impl: numpy
    nports: '1'
    samp_rate: samp_rate
    showports: 'False'
    size: '1024'
    title: None
    ylabel: Amplitude
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import matplotlib.pyplot as plt
      import numpy as np

      plt.plot(np.real(fg.snk.data()))
      plt.plot(np.imag(fg.snk.data()))
      plt.figure()
      plt.plot(np.real(fg.snk_0.data()))

      plt.plot(np.imag(fg.snk_0.data()))
      plt.show()
    section: main_after_stop
  states: {state: disabled}
- name: snk
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {state: disabled}
- name: snk_0
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    T: complex
    center_freq: freq
    gain: '15'
    impl: cpu
    samp_rate: samp_rate
    showports: 'False'
  states: {}
- name: stereo_audio_lpf
  id: filter_fft_filter
  parameters:
    decimation: audio_decim
    impl: cpu
    nthreads: '0'
    samp_delay: '0'
    showports: 'False'
    taps: audio_filter_coeffs
    type_inst: fff
  states: {}
- name: stereo_carrier_bpf
  id: filter_fft_filter
  parameters:
    decimation: '1'
    impl: cpu
    nthreads: '0'
    samp_delay: '0'
    showports: 'False'
    taps: stereo_carrier_filter_coeffs
    type_inst: fff
  states: {}
- name: streamops_delay_0
  id: streamops_delay
  parameters:
    dly: samp_delay
    impl: cpu
    itemsize: gr.sizeof_float
    showports: 'False'
  states: {}
- name: streamops_head_0
  id: streamops_head
  parameters:
    impl: cpu
    itemsize: '0'
    nitems: '10000'
    showports: 'False'
  states: {state: disabled}
- name: streamops_head_0_0
  id: streamops_head
  parameters:
    impl: cpu
    itemsize: '0'
    nitems: '10000'
    showports: 'False'
  states: {state: disabled}

connections:
- [analog_left_fm_deemph, '0', blocks_null_sink_0, '0']
- [analog_left_fm_deemph, '0', math_multiply_const_0, '0']
- [analog_left_fm_deemph, '0', streamops_head_0, '0']
- [analog_noise_source_0, '0', mono_audio_lpf, '0']
- [analog_pll_refout_0, '0', blocks_pilot_multiply, '0']
- [analog_pll_refout_0, '0', blocks_pilot_multiply, '1']
- [analog_quadrature_demod_0, '0', pilot_carrier_bpf, '0']
- [analog_quadrature_demod_0, '0', streamops_delay_0, '0']
- [analog_right_fm_deemph, '0', blocks_null_sink_0_0, '0']
- [analog_right_fm_deemph, '0', math_multiply_const_0_0, '0']
- [analog_right_fm_deemph, '0', streamops_head_0_0, '0']
- [analog_sig_source_0, '0', mono_audio_lpf, '0']
- [blocks_null_source_0, '0', analog_quadrature_demod_0, '0']
- [blocks_pilot_multiply, '0', math_complex_to_imag_0, '0']
- [blocks_stereo_multiply, '0', stereo_audio_lpf, '0']
- [fileio_file_source_0, '0', analog_quadrature_demod_0, '0']
- [filter_fft_filter_0, '0', analog_quadrature_demod_0, '0']
- [math_add_0, '0', analog_left_fm_deemph, '0']
- [math_complex_to_imag_0, '0', stereo_carrier_bpf, '0']
- [math_multiply_const_0, '0', audio_alsa_sink_0, '0']
- [math_multiply_const_0_0, '0', audio_alsa_sink_0, '1']
- [math_sub_0, '0', analog_right_fm_deemph, '0']
- [mono_audio_lpf, '0', math_add_0, '1']
- [mono_audio_lpf, '0', math_sub_0, '0']
- [mono_audio_lpf, '0', pyqtgraph_pg_time_sink_0_0, '0']
- [pilot_carrier_bpf, '0', analog_pll_refout_0, '0']
- [soapy_rtlsdr_source_0, '0', filter_fft_filter_0, '0']
- [stereo_audio_lpf, '0', math_add_0, '0']
- [stereo_audio_lpf, '0', math_sub_0, '1']
- [stereo_audio_lpf, '0', pyqtgraph_pg_time_sink_0, '0']
- [stereo_carrier_bpf, '0', blocks_stereo_multiply, '0']
- [streamops_delay_0, '0', blocks_stereo_multiply, '1']
- [streamops_delay_0, '0', mono_audio_lpf, '0']
- [streamops_head_0, '0', snk, '0']
- [streamops_head_0_0, '0', snk_0, '0']

metadata:
  file_format: 1
