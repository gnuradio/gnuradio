<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cc_ber</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>35000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framebits</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>ber_generator</key>
<param><key>id</key><value>ber_generator_0</value></param>
<param><key>generic_encoder</key><value>enc</value></param>
<param><key>generic_decoder</key><value>dec</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
<param><key>esno</key><value>esno</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>berlimit</key><value>-5.0</value></param>
<param><key>threading</key><value>"None"</value></param>
<param><key>berminerrors</key><value>10000</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_0</value></param>
<param><key>ymin</key><value>-1.25</value></param>
<param><key>ymax</key><value>1.25</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>style1</key><value>3</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>alpha1</key><value>0.5</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>-10</value></param>
<param><key>max</key><value>10</value></param>
<param><key>label1</key><value>BER</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
</block>
<connection><source_block_id>ber_generator_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ber_generator_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
