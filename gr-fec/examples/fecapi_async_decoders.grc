options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_async_decoders
    output_language: python
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_ccsds
  id: variable_ccsds_encoder_def
  parameters:
    framebits: MTU*8
    mode: fec.CC_TERMINATED
    ndim: '0'
    state_start: '0'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
    rep: rep
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: pkt_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pkt_len
    packet_len: frame_size
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: pkt_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (frame_size//15)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: dec_cc
    mtu: MTU
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: enc_ccsds
    mtu: MTU
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '30'
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    color1: '"blue"'
    color2: '"red"'
    label1: Decoded
    label2: Input
    nconnections: '2'
    size: '512'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_pdu_to_tagged_stream_0, '0', digital_map_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, fec_async_encoder_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, fec_async_decoder_0, in]
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0_1, '0']
- [fec_async_decoder_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [fec_async_encoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
