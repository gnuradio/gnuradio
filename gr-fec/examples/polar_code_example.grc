options:
  parameters:
    author: Johannes Demel
    category: Custom
    generate_options: qt_gui
    id: polar_code_example
    output_language: python
    title: POLAR code example flowgraph
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: n_info_bits
  id: variable
  parameters:
    value: block_size // 2
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Noive Voltage
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.1'
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: block_size
    channel: polar.CHANNEL_TYPE_BEC
    design_snr: '0.0'
    mu: '32'
    num_info_bits: n_info_bits
  states: {}
- name: polar_decoder
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    ndim: '0'
    num_info_bits: n_info_bits
  states: {}
- name: polar_encoder
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: n_info_bits
  states: {}
- name: polar_scld
  id: variable_polar_decoder_sc_list_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    max_list_size: '8'
    ndim: '0'
    num_info_bits: n_info_bits
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 350e3
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: short
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: short
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: 2 ** 10 +1
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: short
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: short
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1.0'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_char_to_short_0_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_short_to_char_0_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: polar_decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: polar_encoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,1
    label1: BER
    name: Coded
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,1,1,1
    label1: BER
    max: '0'
    min: '-10'
    name: Uncoded
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 1,0,1,1
    label1: Transmitted
    label2: Received
    name: Coded
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 1,1,1,1
    label1: Transmitted
    label2: Received
    name: Uncoded
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input_packed
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: input_unpacked
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input_packed
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: input_packed
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: input_packed
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: input_unpacked
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_fastnoise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_source_x_0, '0', fec_ber_bf_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_short_to_char_0, '0']
- [blocks_add_xx_0_0, '0', blocks_short_to_char_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_short_0, '0', blocks_add_xx_0, '0']
- [blocks_char_to_short_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0, '0', fec_ber_bf_0, '1']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', fec_ber_bf_0_0, '1']
- [blocks_short_to_char_0, '0', digital_map_bb_0, '0']
- [blocks_short_to_char_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0_2, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_encoder_0, '0', blocks_char_to_short_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_1, '0']
- [virtual_source_0_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [virtual_source_0_1, '0', blocks_char_to_short_0_0, '0']

metadata:
  file_format: 1
