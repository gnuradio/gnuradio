options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_polar_decoder_examples
    output_language: python
    title: Polar decoder examples
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    comment: |-
      codeword size of polar codes.

      MUST be a power of 2!
      MUST be greater than 'frame_size'.
    value: '512'
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: block_size
    channel: polar.CHANNEL_TYPE_BEC
    comment: |-
      Block is used to configure polar encoders and decoders.

      returns dictionary with requested configuration.

      most important dict values: 'values' and 'positions'
    design_snr: '0.0'
    mu: '32'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_decoder_sc
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: block_size
    comment: |-
      Standard 'Successive Cancellation' decoder.

      performs better with greater block size.
      This is due to stronger polarization at higher block sizes.
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_encoder_sc
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e3)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: pkt_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pkt_len
    packet_len: frame_size
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: pkt_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: pkt_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (frame_size//15)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: polar_decoder_sc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: polar_encoder_sc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '30'
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    color1: '"blue"'
    color2: '"red"'
    label1: Decoded
    label2: Input
    nconnections: '2'
    size: '512'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '140'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, fec_async_encoder_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, fec_async_decoder_0, in]
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0_1, '0']
- [fec_async_decoder_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [fec_async_encoder_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
