options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: tpc_ber_curve_gen
    output_language: python
  states: {}

blocks:
- name: dec_tpc_0
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '0'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: dec_tpc_1
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '1'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: dec_tpc_2
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '2'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: dec_tpc_3
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '3'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: dec_tpc_4
  id: variable_tpc_decoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    decoder_type: '4'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    max_iter: '6'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_tpc_0
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_tpc_1
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_tpc_2
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_tpc_3
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: enc_tpc_4
  id: variable_tpc_encoder_def
  parameters:
    bval: '9'
    col_poly: '[43]'
    dim1: len(esno_0)
    dim2: '1'
    kcol: '6'
    krow: '26'
    ndim: '2'
    qval: '3'
    row_poly: '[3]'
  states: {}
- name: esno_0
  id: variable
  parameters:
    value: 'numpy.arange(0, 8, .5) '
  states: {}
- name: framebits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[79, 109]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '35000000'
  states: {}
- name: fec_bercurve_generator_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc_2
    encoder_list: enc_tpc_2
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc_1
    encoder_list: enc_tpc_1
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc_0
    encoder_list: enc_tpc_0
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_1
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc_3
    encoder_list: enc_tpc_3
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_1_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_tpc_4
    encoder_list: enc_tpc_4
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    alpha1: '1'
    alpha2: '1'
    alpha3: '1'
    berlimit: '-10'
    berminerrors: '1000'
    color3: '"magenta"'
    color4: '"dark red"'
    color5: '"Dark Blue"'
    esno: esno_0
    label1: Linear LOG-MAP
    label2: MAX LOG-MAP
    label3: Constant LOG-MAP
    label4: LOG-MAP (LUT)
    label5: LOG-MAP (C Correction)
    marker2: '1'
    num_curves: '5'
    style2: '2'
    style3: '5'
    style4: '5'
    style5: '4'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
  states: {bus_sink: true}

connections:
- [fec_bercurve_generator_0, '32', qtgui_bercurve_sink_0, '162']
- [fec_bercurve_generator_0_0, '32', qtgui_bercurve_sink_0, '161']
- [fec_bercurve_generator_0_0_0, '32', qtgui_bercurve_sink_0, '160']
- [fec_bercurve_generator_0_1, '32', qtgui_bercurve_sink_0, '163']
- [fec_bercurve_generator_0_1_0, '32', qtgui_bercurve_sink_0, '164']

metadata:
  file_format: 1
