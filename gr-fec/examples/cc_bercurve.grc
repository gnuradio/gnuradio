<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cc_bercurve</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>framebits</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>35000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>numpy.arange(0, 8, .5) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno_0</value></param>
<param><key>value</key><value>numpy.arange(0, 2, .5) </value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>dim1</key><value>len(esno_0)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>framebits</value></param>
<param><key>k</key><value>k</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>strb</key><value>"streaming"</value></param>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>fec_bercurve_generator_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>esno</key><value>esno_0</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
<param><key>encoder_list</key><value>None</value></param>
<param><key>decoder_list</key><value>None</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>len(esno_0)*2</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate_0</value></param>
<param><key>nconnections</key><value>len(esno_0)*2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label6</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label8</key><value></value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label9</key><value></value></param>
<param><key>color9</key><value>"dark green"</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>fec_bercurve_generator_0</value></param>
<param><key>esno</key><value>esno_0</value></param>
<param><key>samp_rate</key><value>samp_rate_0</value></param>
<param><key>encoder_list</key><value>enc</value></param>
<param><key>decoder_list</key><value>dec</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>blocks_streams_to_stream</key>
<param><key>id</key><value>blocks_streams_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_streams</key><value>len(esno_0)*2</value></param>
<bus_sink>1</bus_sink>
</block>
<connection><source_block_id>blocks_streams_to_stream_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>fec_bercurve_generator_0</source_block_id><sink_block_id>blocks_streams_to_stream_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
</flow_graph>
