<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polar_encoder_decoder_chain</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value># for rough throughput measurements.

    tb = polar_encoder_decoder_chain()
    start_time = time.time()
    tb.start()
    tb.wait()
    stop_time = time.time()
    diff = stop_time - start_time
    throughput = tb.head_samps / diff
    print("execution time: {0:.6f} for {1:e} samples with throughput: {2:,.2f} Sps".format(diff, tb.head_samps, throughput))</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>POLAR Encoder and Decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_size</value></param>
<param><key>value</key><value>2 ** 11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>head_samps</value></param>
<param><key>value</key><value>2 ** 32# encoder: 32, decoder: 23</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_info_bits</value></param>
<param><key>value</key><value>block_size / 2</value></param>
</block>
<block>
<key>variable_polar_code_configurator</key>
<param><key>id</key><value>polar_config</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>channel</key><value>bsc</value></param>
<param><key>design_snr</key><value>-1.0</value></param>
<param><key>mu</key><value>32</value></param>
</block>
<block>
<key>variable_polar_decoder_sc_def</key>
<param><key>id</key><value>polar_decoder</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_polar_encoder_def</key>
<param><key>id</key><value>polar_encoder</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_polar_decoder_sc_list_def</key>
<param><key>id</key><value>polar_scld</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>max_list_size</key><value>8</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>2 ** 10 </value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1.0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>-0.5</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>head_samps</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>polar_scld</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>polar_encoder</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
