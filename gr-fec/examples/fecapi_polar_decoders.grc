options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_polar_decoders
    output_language: python
    title: Polar Decoders Example
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    comment: |-
      codeword size of polar codes.

      MUST be a power of 2!
      MUST be greater than 'frame_size'.
    value: '512'
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: block_size
    channel: polar.CHANNEL_TYPE_BEC
    comment: |-
      Block is used to configure polar encoders and decoders.

      returns dictionary with requested configuration.

      most important dict values: 'values' and 'positions'
    design_snr: '0.0'
    mu: '32'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_decoder_sc
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: block_size
    comment: |-
      Standard 'Successive Cancellation' decoder.

      performs better with greater block size.
      This is due to stronger polarization at higher block sizes.
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_decoder_scl
  id: variable_polar_decoder_sc_list_def
  parameters:
    block_size: block_size
    comment: |-
      Advanced 'Successive Cancellation List' decoder

      Greater list size usually results in better decoding performance.
      But it is computationally more heavy.
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    max_list_size: '8'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_encoder_sc
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_encoder_scl
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (frame_size//15)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127]
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: polar_decoder_scl
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: polar_decoder_sc
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_dummy
    puncpat: puncpat
    threadtype: none
  states: {}
- name: fec_extended_encoder_1
  id: fec_extended_encoder
  parameters:
    encoder_list: polar_encoder_scl
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0
  id: fec_extended_encoder
  parameters:
    encoder_list: polar_encoder_sc
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_dummy
    puncpat: puncpat
    threadtype: capillary
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '30'
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    label1: Input
    label2: Dummy
    label3: Polar with SC decoder
    label4: Polar with SC list decoder
    nconnections: '4'
    size: '2048'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0_1, '0']
- [blocks_char_to_float_0_2_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_1_0_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_2, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0_0, '0']
- [fec_extended_decoder_0_1, '0', blocks_char_to_float_0_0_0, '0']
- [fec_extended_decoder_0_1_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [fec_extended_encoder_1, '0', digital_map_bb_0_0, '0']
- [fec_extended_encoder_1_0, '0', digital_map_bb_0_0_0, '0']
- [fec_extended_encoder_1_0_0, '0', digital_map_bb_0_0_0_0, '0']

metadata:
  file_format: 1
