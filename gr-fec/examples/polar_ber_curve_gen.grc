options:
  parameters:
    author: Johannes Demel
    category: Custom
    generate_options: qt_gui
    id: polar_ber_curve_gen
    output_language: python
    title: polar code BER curve generator
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    dim1: len(esno)
    dim2: '1'
    framebits: frame_size
    k: k
    mode: fec.CC_STREAMING
    ndim: '2'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    dim1: len(esno)
    dim2: '1'
    framebits: frame_size
    k: k
    mode: fec.CC_STREAMING
    ndim: '2'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: esno
  id: variable
  parameters:
    value: numpy.arange(-1, 4, 0.5)
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: int(block_size / 2)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: list_size
  id: variable
  parameters:
    value: '8'
  states: {}
- name: n_info_bits
  id: variable
  parameters:
    value: int( block_size / 2 )
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: block_size
    channel: polar.CHANNEL_TYPE_BEC
    design_snr: '0.0'
    mu: '32'
    num_info_bits: n_info_bits
  states: {}
- name: polar_decoder
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: block_size
    dim1: len(esno)
    dim2: '1'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    ndim: '2'
    num_info_bits: n_info_bits
  states: {}
- name: polar_encoder
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    dim1: len(esno)
    dim2: '1'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '2'
    num_info_bits: n_info_bits
  states: {}
- name: polar_encoder_scld
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    dim1: len(esno)
    dim2: '1'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '2'
    num_info_bits: n_info_bits
  states: {}
- name: polar_scld
  id: variable_polar_decoder_sc_list_def
  parameters:
    block_size: block_size
    dim1: len(esno)
    dim2: '1'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    max_list_size: list_size
    ndim: '2'
    num_info_bits: n_info_bits
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[79, 109]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 350e3
  states: {}
- name: polar_curve_gen_sc
  id: fec_bercurve_generator
  parameters:
    decoder_list: polar_decoder
    encoder_list: polar_encoder
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
    threadtype: '"none"'
  states: {bus_source: true}
- name: polar_curve_gen_scld
  id: fec_bercurve_generator
  parameters:
    decoder_list: polar_scld
    encoder_list: polar_encoder_scld
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
    threadtype: '"none"'
  states: {bus_source: true}
- name: polar_curve_gen_scld_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_cc
    encoder_list: enc_cc
    esno: esno
    puncpat: '''11'''
    samp_rate: '3200000'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-7.0'
    berminerrors: '100'
    curvenames: '[''POLAR decoder'', ''POLAR decoder list'', ''CC'']'
    esno: esno
    label1: POLAR decoder
    label2: POLAR list decoder
    label3: CC convolutional
    num_curves: '3'
  states: {bus_sink: true}

connections:
- [polar_curve_gen_sc, '20', qtgui_bercurve_sink_0, '60']
- [polar_curve_gen_scld, '20', qtgui_bercurve_sink_0, '61']
- [polar_curve_gen_scld_0, '20', qtgui_bercurve_sink_0, '62']

metadata:
  file_format: 1
