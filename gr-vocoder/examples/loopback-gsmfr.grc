options:
  parameters:
    author: Martin Braun
    category: Custom
    description: An example how to use the GSM-FR Vocoder
    generate_options: qt_gui
    id: loopback_gsmfr
    output_language: python
    title: GSM Full-Rate 06.10 Codec Loopback Test
  states: {}

blocks:
- name: play_encoded
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Encode Audio
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: scale
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: play_encoded
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '33'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '33'
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: speech_audio_at_48_kHz.wav
    repeat: 'True'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    name: Audio Post-Encoding
    size: '1024'
    srate: '8000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    name: Audio Pre-Encoding
    size: '1024'
    srate: '8000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Encoded Speech
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Unencoded Speech
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Decoded Speech
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Encoded Speech
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Unencoded Speech
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Decoded Speech
  states: {}
- name: vocoder_gsm_fr_decode_ps_0
  id: vocoder_gsm_fr_decode_ps
  parameters: {}
  states: {}
- name: vocoder_gsm_fr_encode_sp_1
  id: vocoder_gsm_fr_encode_sp
  parameters: {}
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_gsm_fr_encode_sp_1, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_1, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_2, '0']
- [blocks_stream_to_vector_0, '0', vocoder_gsm_fr_decode_ps_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_1, '0', blocks_selector_0, '0']
- [virtual_source_1_0, '0', blocks_selector_0, '1']
- [vocoder_gsm_fr_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_gsm_fr_encode_sp_1, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
