options:
  parameters:
    author: A. Maitland Bottoms
    category: Custom
    copyright: 2016,2019 Free Software Foundation, Inc.
    description: A FreeDV Modulator
    generate_options: qt_gui
    id: grfreedv
    output_language: python
    title: GNU Radio FreeDV
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch slider
    min_len: '256'
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-127'
    step: '1'
    stop: '128'
    value: '-120'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /usr/share/codec2/wav/all.wav
    repeat: 'True'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    squelch_enable: 'True'
    squelch_thresh: squelch
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    tx_bpf_val: 'True'
    txt_msg: '''GNU Radio'''
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_short_to_float_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_float_0, '0']
- [vocoder_freedv_rx_ss_0, text, blocks_message_debug_0, print]
- [vocoder_freedv_tx_ss_0, '0', vocoder_freedv_rx_ss_0, '0']

metadata:
  file_format: 1
