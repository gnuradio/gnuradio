options:
  parameters:
    author: dl1ksv
    generate_options: qt_gui
    id: Messagetext
    output_language: python
    title: Display a test message
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(" Gutta cavat lapidem non vi sed saepe cadendo\nmanus manum lavat")
    period: '1000'
  states: {}
- name: qtgui_display_text_msg_0
  id: qtgui_display_text_msg
  parameters:
    label: ' Received text message'
    maxlines: '6'
    messagekey: TEST
    splitlength: '42'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, qtgui_display_text_msg_0, text]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-84-g6963cf5a
