options:
  parameters:
    generate_options: qt_gui
    id: test_toggleswitch2
    output_language: python
    title: Test Toggle Switch
  states: {}

blocks:
- name: ledstate_id_0
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: Toggle
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 1,0,1,1
    label: '"State"'
    state: '0'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [ledstate_id_0, state, blocks_message_debug_0, print]
- [ledstate_id_0, state, qtgui_ledindicator_0, state]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
