options:
  parameters:
    generate_options: qt_gui
    id: test_graphic_overlay
    output_language: python
    title: Test Graphic Item Overlay
  states: {}

blocks:
- name: overlayfile
  id: variable
  parameters:
    value: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/satdishsmall.png"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import subprocess
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/earth.jpg"
    height: '240'
    scaleImage: 'True'
    width: '320'
  states: {}
- name: qtgui_graphicoverlay_0
  id: qtgui_graphicoverlay
  parameters:
    overlayList: '[{''filename'':overlayfile,''x'':10,''y'':0,''scalefactor'':1},{''filename'':overlayfile,''x'':20,''y'':20,''scalefactor'':2},{''filename'':overlayfile,''x'':30,''y'':40,''scalefactor'':2},{''filename'':overlayfile,''x'':40,''y'':60,''scalefactor'':3},{''filename'':overlayfile,''x'':50,''y'':80,''scalefactor'':4}]'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [qtgui_graphicoverlay_0, overlay, blocks_message_debug_0, print]
- [qtgui_graphicoverlay_0, overlay, qtgui_graphicitem_0, overlay]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
