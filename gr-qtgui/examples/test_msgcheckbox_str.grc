options:
  parameters:
    generate_options: qt_gui
    id: test_msgchkstr
    output_language: python
    title: Test Msg Checkbox
  states: {}

blocks:
- name: filename
  id: variable_qtgui_msgcheckbox
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: Change Image
    outputmsgname: filename
    pressed: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/earth.jpg"
    released: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/gnuradio_logo.png"
    type: string
    value: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/gnuradio_logo.png"
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import subprocess
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/gnuradio_logo.png"
    gui_hint: 1,0,1,1
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [filename, state, blocks_message_debug_0, print]
- [filename, state, qtgui_graphicitem_0, filename]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
