options:
  parameters:
    author: dl1ksv
    category: '[DL1KSV]/Tools'
    description: Decodes apt pictures
    generate_options: hb
    id: decodeApt
    output_language: python
    title: Decodes apt pictures from noaa
  states: {}

blocks:
- name: Decim
  id: variable
  parameters:
    value: samp_rate_in/96000
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.05'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: int(Decim)
    gain: '1'
    high_cutoff_freq: '34000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate_in
    type: fir_filter_ccc
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '10'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '100'
    samp_rate: samp_rate_in/Decim
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '255'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '1'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    value: '255'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: Trigger
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '480'
    fbw: '0.2'
    interp: '416'
    taps: ''
    type: fff
  states: {}
- name: samp_rate_in
  id: parameter
  parameters:
    label: Samplerate
    type: intx
    value: '192000'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_max_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', band_pass_filter_0_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_1, '0']
- [band_pass_filter_0, '0', blocks_divide_xx_0, '0']
- [band_pass_filter_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_mag_1, '0', blocks_max_xx_0, '0']
- [blocks_divide_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_float_to_complex_0, '0', blocks_divide_xx_0, '1']
- [blocks_float_to_complex_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_float_to_uchar_0, '0', pad_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_complex_1, '0']
- [blocks_keep_one_in_n_1, '0', blocks_float_to_complex_1, '1']
- [blocks_max_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_1, '0']
- [dc_blocker_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [dc_blocker_xx_0, '0', blocks_skiphead_0, '0']
- [pad_source_0, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', pad_sink_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-122-ge87d616c
