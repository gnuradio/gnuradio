options:
  parameters:
    generate_options: qt_gui
    id: test_compass_stream
    output_language: python
    title: Test Compass
  states: {}

blocks:
- name: az
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: AZ
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '360'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: az
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    backgroundColor: white
    fullNeedle: '1'
    gui_hint: 1,0,1,1
    min_size: '250'
    name: Azimuth
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_compass_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
