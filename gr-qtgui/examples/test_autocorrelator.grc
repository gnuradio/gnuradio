options:
  parameters:
    generate_options: qt_gui
    id: test_autocorrelator
    output_language: python
  states: {}

blocks:
- name: fac_decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fac_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2441e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: window_time
  id: variable
  parameters:
    value: samp_rate/fac_size
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '512'
    gui_hint: 2,0,1,3
    sampRate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,3
    plotconst: 'False'
    showports: 'True'
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_auto_correlator_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
