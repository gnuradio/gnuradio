options:
  parameters:
    description: Switch bands at runtime to change the Digital Number Control limits.
    generate_options: qt_gui
    id: test_digitalnumcontrol_limits
    output_language: python
    title: Digital Number Control Runtime Limits
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Band
    label0: FM
    label1: Airband
    label2: UHF
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: QtWidgets.QVBoxLayout
    type: int
    value: '0'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,1,1,1
    lbl: Frequency
    maxFreqHz: '[108e6, 137e6, 440e6][band]'
    minFreqHz: '[88e6, 118e6, 430e6][band]'
    value: 100e6
  states: {}
- name: freq_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: 'Flowgraph value: '
    type: real
    value: freq
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
