options:
  parameters:
    generate_options: qt_gui
    id: show_controls
    output_language: python
    title: Control Demo
  states: {}

blocks:
- name: angle
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,0,1,1
    label: Angle
    maximum: '360'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '25'
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,2
    lbl: Frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 139.712e6
  states: {}
- name: gain
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,3,1,1
    label: Gain
    maximum: '100'
    minimum: '0'
    relBackgroundColor: aqua
    showvalue: 'False'
    type: int
    value: '6'
  states: {}
- name: ledstatus
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,2,1,1
    initPressed: 'True'
    label: LED
    pressBackgroundColor: green
    pressed: 'True'
    relBackgroundColor: red
    released: 'False'
    type: bool
    value: 'True'
  states: {}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    gui_hint: 1,4,1,1
    label: Gain
    maximum: '100'
    minimum: '0'
    msize: '300'
    position: '2'
    type: int
    value: gain
  states: {}
- name: qtgui_levelgauge_0_0
  id: qtgui_levelgauge
  parameters:
    backgroundColor: yellow
    barColor: red
    gui_hint: 2,4,1,1
    isVertical: 'False'
    label: Gain
    maximum: '100'
    minimum: '0'
    msize: '300'
    position: '2'
    showValue: 'True'
    type: int
    value: gain
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import subprocess
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    backgroundColor: white
    fullNeedle: '1'
    gui_hint: 1,1,2,2
    min_size: '100'
    name: Azimuth
    usemsg: 'True'
  states: {}
- name: qtgui_graphicitem_0
  id: qtgui_graphicitem
  parameters:
    file: subprocess.getoutput("gnuradio-config-info --prefix") + "/share/gnuradio/examples/qt-gui/earth.jpg"
    gui_hint: 0,4,1,1
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,3,1,1
    label: AOS
    state: ledstatus
  states: {}

connections:
- [angle, value, qtgui_compass_0, angle]
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
