options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: qt_example_vector_sink
    output_language: python
    title: QT GUI Vector Sink Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: veclen
  id: variable
  parameters:
    value: '512'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
    vlen: veclen
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: veclen
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
    vlen: veclen
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: range(veclen)
    vlen: veclen
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"A noisy line"'
    vlen: veclen
    x_start: '0'
    x_step: 1.0/veclen
    ymax: '512'
    ymin: '0'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [qtgui_vector_sink_f_0, xval, blocks_message_debug_0, print]

metadata:
  file_format: 1
