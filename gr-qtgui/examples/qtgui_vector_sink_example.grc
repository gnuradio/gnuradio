<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qt_example_vector_sink</value></param>
<param><key>title</key><value>QT GUI Vector Sink Example</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>veclen</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>veclen</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>veclen</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vector</key><value>range(veclen)</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>veclen</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>veclen</value></param>
</block>
<block>
<key>qtgui_vector_sink_x</key>
<param><key>id</key><value>qtgui_vector_sink_x_0</value></param>
<param><key>name</key><value>"A noisy line"</value></param>
<param><key>vlen</key><value>veclen</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0/veclen</value></param>
<param><key>x_axis_label</key><value>"x-Axis"</value></param>
<param><key>y_axis_label</key><value>"y-Axis"</value></param>
<param><key>x_units</key><value>"x"</value></param>
<param><key>y_units</key><value>"y"</value></param>
<param><key>ref_level</key><value>.5*veclen</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>False</value></param>
<param><key>average</key><value>1.0</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>veclen</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>update_time</key><value>0.10</value></param>
<param><key>showports</key><value>False</value></param>
<param><key>label1</key><value>Up</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>label2</key><value></value></param>
<param><key>width2</key><value>1</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>alpha2</key><value>1.0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_vector_sink_x_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>xval</source_key><sink_key>print</sink_key></connection>
</flow_graph>
