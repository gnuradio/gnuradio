options:
  parameters:
    generate_options: qt_gui
    id: test_dignum
    output_language: python
    title: Test Digital Number Control
  states: {}

blocks:
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,1,1,1
    lbl: Frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: Current Freq
    type: real
    value: freq
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,1
    key: value
    label: Msg-based input
    type: float
    value: 90e6
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [freq, valueout, blocks_message_debug_0, print]
- [qtgui_edit_box_msg_0, msg, freq, valuein]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
