options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: grc_qt_example
    output_language: python
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Signal Amplitude
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Signal Frequency
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: samp_rate/100.0
    stop: samp_rate/2.0
    value: '1000'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '-42'
    taps: 1.0 + 0.0j
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: QT GUI Plot
    plotconst: 'False'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
