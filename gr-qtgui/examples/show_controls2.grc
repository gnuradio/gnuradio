options:
  parameters:
    generate_options: qt_gui
    id: show_controls2
    output_language: python
    title: gr-guiextra
  states: {}

blocks:
- name: qtgui_dialgauge_0
  id: qtgui_dialgauge
  parameters:
    barColor: red
    gui_hint: 0,2,1,1
    maximum: '360.0'
    minimum: '0.0'
    msize: '160'
    showValue: 'True'
    type: real
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: setval
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 0,0,1,1
    label: Dial
    maximum: '3600.0'
    minimum: '0.0'
    scaleFactor: 1/10
    showvalue: 'False'
    type: real
    value: '1200.0'
  states: {}
- name: toggleswitch
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 1,0,1,1
    initPressed: 'False'
    label: Toggle Switch
    pressed: '1'
    released: '0'
    switchOffBackground: blue
    type: int
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [setval, value, qtgui_dialgauge_0, value]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
