options:
  parameters:
    author: Martin Braun <martin.braun@ettus.com>
    description: Standalone test for the RFNoC Fosphor GL sink.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    hier_block_src_path: ''
    id: test_rfnoc_f15_display
    output_language: python
    title: QT GUI RFNoC Fosphor Display Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1) * 500
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1,) * freq + (0,) * freq
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: qtgui_rfnoc_f15_gl_sink_0
  id: qtgui_rfnoc_f15_gl_sink
  parameters:
    alpha: '0.1'
    center_freq: freq
    epsilon: '0.99'
    frame_rate: '30'
    grid_enabled: 'True'
    histo_decim: '64'
    input_decim: '1'
    palette: iron
    samp_rate: samp_rate
    scale: '1.0'
    tdecay: '1024.0'
    trise: '16.0'
    wf_decim: '16'
    wf_lines: '512'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_gfsk_mod_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_rfnoc_f15_gl_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1181-g5358e35e
