options:
  parameters:
    generate_options: qt_gui
    id: test_toggle
    output_language: python
    title: Test Toggle Button
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: state
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: State
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,1,1,1
    label: '"State"'
    state: state
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [state, state, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
