options:
  parameters:
    author: dl1ksv
    category: Custom
    description: Decode an apt picture from Noaa
    generate_options: qt_gui
    id: NooTest
    output_language: python
    title: Test Nooa Rx
  states: {}

blocks:
- name: Force
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label: Force Display
    label0: Automatic start
    label1: Force start
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: Rx
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,5,6
    label0: Spectrum and Control
    label1: Image
    num_tabs: '2'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: Force
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '30'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/schroer/Projekte/sigmf/noaa_sigmf.sigmf-meta
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '15'
    init: '0'
    low: '10'
  states: {}
- name: blocks_threshold_ff_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0.9'
    init: '0'
    low: '-1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*3
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/schroer/testsounds/Noaa_2019-07-29T17:30_fcdpp.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: decodeApt_0
  id: decodeApt
  parameters:
    gain: '128'
    samp_rate_in: samp_rate
  states: {}
- name: fir_filter_xxx_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: (-14,-14,-14,-14,-14,-14,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,18,18,-14,-14,-14)
    type: fff
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '10000'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1,samp_rate,-96000,96000,500)
  states: {}
- name: qtgui_display_image_0
  id: qtgui_display_image
  parameters:
    displaybottomup: 'True'
    gui_hint: Rx@1
    imageheight: '1400'
    imagewidth: '2080'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: Rx@0
    label1: Start Trigger
    label2: Synca filtered normalized
    label3: Decoded signal
    name: QT GUI Plot
    nconnections: '3'
    size: '2080'
    srate: samp_rate/10
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: Rx@0
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_threshold_ff_1_0, '0']
- [blocks_delay_0, '0', qtgui_display_image_0, '0']
- [blocks_float_to_char_0, '0', qtgui_display_image_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_threshold_ff_1_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [decodeApt_0, '0', blocks_delay_0, '0']
- [decodeApt_0, '1', fir_filter_xxx_0_2, '0']
- [decodeApt_0, '1', qtgui_time_sink_x_0, '2']
- [fir_filter_xxx_0_2, '0', blocks_threshold_ff_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', decodeApt_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-122-ge87d616c
