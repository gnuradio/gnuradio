options:
  parameters:
    generate_options: qt_gui
    id: test_compass
    output_language: python
    title: Test Compass
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_dial_control_0
  id: variable_qtgui_dial_control
  parameters:
    label: Angle
    maximum: '360'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    backgroundColor: white
    fullNeedle: '1'
    min_size: '250'
    name: Azimuth
    usemsg: 'True'
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [variable_qtgui_dial_control_0, value, qtgui_compass_0, angle]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
