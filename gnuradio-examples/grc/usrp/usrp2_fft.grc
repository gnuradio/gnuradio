<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp2_fft</value></param>
<param><key>title</key><value>USRP2 FFT Plotter</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>FFT waveform plot</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e6/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>label</key><value>USRP2 Freq (Hz)</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>min</key><value>2.4e9</value></param>
<param><key>max</key><value>2.5e9</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>tun_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>ref_level</key><value>10</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
</block>
<block>
<key>usrp2_source_xxxx</key>
<param><key>id</key><value>usrp2_source_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value></value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>tun_freq</value></param>
<param><key>gain</key><value>0</value></param>
</block>
<connection><source_block_id>usrp2_source_xxxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
