<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_wbfm_receive</value></param>
<param><key>title</key><value>USRP WBFM Receive</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>WBFM Receive with Basic RX or TV RX</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 4</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source_x</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>(freq+fine)*1e6</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>side</key><value>A</value></param>
<param><key>rx_ant</key><value>None</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>64e6/decim</value></param>
<param><key>baseband_freq</key><value>(freq+fine)*1e6</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>grid_pos</key><value>2, 0, 2, 4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency (MHz)</value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>87.5</value></param>
<param><key>max</key><value>108.0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine</value></param>
<param><key>label</key><value>Fine Freq (MHz)</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-.1</value></param>
<param><key>max</key><value>.1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 2</value></param>
</block>
<block>
<key>blks2_wfm_rcv</key>
<param><key>id</key><value>blks2_wfm_rcv</value></param>
<param><key>quad_rate</key><value>64e6/decim</value></param>
<param><key>audio_decimation</key><value>10</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>samp_rate</key><value>32000</value></param>
</block>
<connection><source_block_id>usrp_simple_source_x</source_block_id><sink_block_id>blks2_wfm_rcv</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_simple_source_x</source_block_id><sink_block_id>wxgui_fftsink2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv</source_block_id><sink_block_id>gr_multiply_const_vxx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
