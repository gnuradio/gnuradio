<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64e6/200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>value</key><value>int(100e6)</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>tone1</value></param>
<param><key>amp</key><value>tone_ampl</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>tone2</value></param>
<param><key>amp</key><value>tone_ampl</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_side</value></param>
<param><key>value</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>usrp_simple_sink_x</key>
<param><key>id</key><value>usrp_simple_sink_x</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>interpolation</key><value>400</value></param>
<param><key>frequency</key><value>tun_freq</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>side</key><value>tx_side</value></param>
<param><key>transmit</key><value></value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>usrp_simple_source_x</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>0</value></param>
<param><key>decimation</key><value>200</value></param>
<param><key>frequency</key><value>tun_freq</value></param>
<param><key>gain</key><value>20</value></param>
<param><key>side</key><value>rx_side</value></param>
<param><key>rx_ant</key><value>rx_ant</value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_ant</value></param>
<param><key>value</key><value>RXA</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>ref_level</key><value>100</value></param>
<param><key>fft_size</key><value>512*2</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>grid_pos</key><value>1, 2, 2, 4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_side</value></param>
<param><key>value</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>gr_noise_source_x</key>
<param><key>id</key><value>gr_noise_source_x</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>gr.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noise_ampl</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>noise_ampl</value></param>
<param><key>label</key><value>Noise Ampl</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_VERTICAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 1, 2, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tone_ampl</value></param>
<param><key>label</key><value>Tone Ampl</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_VERTICAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1, 0, 2, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tone1</value></param>
<param><key>label</key><value>Tone 1</value></param>
<param><key>value</key><value>50e3</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tone2</value></param>
<param><key>label</key><value>Tone 2</value></param>
<param><key>value</key><value>75e3</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0, 4, 1, 4</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>usrp_two_tone_loopback</value></param>
<param><key>title</key><value>USRP Loopback - 2 Tone</value></param>
<param><key>author</key><value>Example</value></param>
<param><key>description</key><value>Loopback test with basic rx and basic tx</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>gr_sig_source_x</source_block_id><sink_block_id>gr_add_xx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x0</source_block_id><sink_block_id>gr_add_xx</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_noise_source_x</source_block_id><sink_block_id>gr_add_xx</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>usrp_simple_source_x</source_block_id><sink_block_id>wxgui_fftsink2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx</source_block_id><sink_block_id>usrp_simple_sink_x</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
