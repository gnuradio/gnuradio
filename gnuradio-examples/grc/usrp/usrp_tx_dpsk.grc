<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_tx_dpsk</value></param>
<param><key>title</key><value>USRP TX DPSK</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2**8</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blks2_dxpsk2_mod</key>
<param><key>id</key><value>blks2_dxpsk2_mod_0</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>usrp_simple_sink_x</key>
<param><key>id</key><value>usrp_simple_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>which</key><value>0</value></param>
<param><key>interpolation</key><value>int(128e6/samp_rate)</value></param>
<param><key>frequency</key><value>bb_freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>side</key><value>A</value></param>
<param><key>transmit</key><value>auto_tr</value></param>
</block>
<block>
<key>usrp2_sink_xxxx</key>
<param><key>id</key><value>usrp2_sink_xxxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value></value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>interpolation</key><value>int(100e6/samp_rate)</value></param>
<param><key>frequency</key><value>bb_freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_ampl</value></param>
<param><key>label</key><value>TX Amplitude</value></param>
<param><key>value</key><value>.2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bb_freq</value></param>
<param><key>value</key><value>2.45e9+freq_off</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_off</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>p2p</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>tx_ampl*p2p/2.</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Transmit Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>bb_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>p2p</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6/4</value></param>
</block>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>blks2_dxpsk2_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk2_mod_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>usrp_simple_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
