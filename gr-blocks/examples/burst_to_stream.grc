options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: burst_to_stream
    output_language: python
    title: Burst to Stream example
  states: {}

blocks:
- name: enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable packets
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: packet_rate
  id: variable_qtgui_entry
  parameters:
    label: Packet sample rate
    type: real
    value: '30000'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    label: Sample rate
    type: real
    value: '100000'
  states: {}
- name: strobe_period
  id: variable_qtgui_entry
  parameters:
    label: Strobe period (ms)
    type: int
    value: '100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.2'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_burst_to_stream_0
  id: blocks_burst_to_stream
  parameters:
    len_tag_key: '"packet_len"'
    propagate_tags: 'True'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: enable
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_c32vector(packet_length, 0.2 * (np.random.randn(packet_length) + 1j * np.random.randn(packet_length))))
    period: strobe_period
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_length
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: packet_length
    samples_per_second: packet_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Enable only one of these parts of the flowgraph
      to test the Burst to Stream with different kinds
      of inputs.
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Tag-triggered Time Sink"'
    size: '10000'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Free-running Time Sink"'
    size: '10000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_1, '0']
- [blocks_burst_to_stream_0, '0', blocks_add_xx_0, '0']
- [blocks_copy_0, '0', blocks_burst_to_stream_0, '0']
- [blocks_message_strobe_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_copy_0, '0']
- [blocks_throttle2_1, '0', blocks_probe_rate_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_copy_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-744-g5776fd3c
