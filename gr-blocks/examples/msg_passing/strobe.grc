options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: strobe
    output_language: python
  states: {}

blocks:
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons( pmt.PMT_NIL, pmt.make_u8vector(512,0) )
    period: '750'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_copy_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0_0, strobe, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_copy_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
