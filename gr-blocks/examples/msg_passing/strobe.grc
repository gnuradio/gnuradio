<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_pdu_to_tagged_stream</key>
<param><key>id</key><value>gr_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>gr_tagged_stream_to_pdu</key>
<param><key>id</key><value>gr_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>gr_kludge_copy</key>
<param><key>id</key><value>gr_kludge_copy_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.cons( pmt.PMT_NIL, pmt.make_u8vector(512,0) )</value></param>
<param><key>period</key><value>750</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>strobe</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>gr_pdu_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_kludge_copy_0</source_block_id><sink_block_id>gr_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_pdu_to_tagged_stream_0</source_block_id><sink_block_id>gr_kludge_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
