<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_msg_hier_topblock</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("UPDATED2")</value></param>
<param><key>period</key><value>3000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("UPDATED")</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>TEST_MSG_HIER</key>
<param><key>id</key><value>TEST_MSG_HIER_0</value></param>
</block>
<connection><source_block_id>TEST_MSG_HIER_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>TEST_MSG_HIER_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>TEST_MSG_HIER_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>TEST_MSG_HIER_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>TEST_MSG_HIER_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
