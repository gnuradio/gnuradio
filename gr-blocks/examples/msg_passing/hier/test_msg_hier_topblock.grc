options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: test_msg_hier_topblock
    output_language: python
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("UPDATED")
    period: '2000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("UPDATED2")
    period: '3000'
  states: {}
- name: test_msg_hier_0
  id: test_msg_hier
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, test_msg_hier_0, TEST_PORT2]
- [blocks_message_strobe_0_0, strobe, test_msg_hier_0, TEST_PORT1]
- [test_msg_hier_0, TEST_PORT0, blocks_message_debug_0, print]
- [test_msg_hier_0, TEST_PORT0, blocks_message_debug_0, store]
- [test_msg_hier_0, TEST_PORT3, blocks_message_debug_0, print]

metadata:
  file_format: 1
