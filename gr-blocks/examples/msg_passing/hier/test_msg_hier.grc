options:
  parameters:
    category: Custom
    generate_options: hb
    id: test_msg_hier
    output_language: python
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16,0x77))
    period: '200'
  states: {}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("OUTPUT2")
    period: '100'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: TEST_PORT0
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: TEST_PORT3
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: TEST_PORT2
    type: message
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: TEST_PORT1
    type: message
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pad_sink_0, in0]
- [blocks_message_strobe_0_1, strobe, pad_sink_0, in0]
- [blocks_message_strobe_0_1, strobe, pad_sink_1, in0]
- [pad_source_0, out0, blocks_message_strobe_0, set_msg]
- [pad_source_1, out0, blocks_message_strobe_0, set_msg]

metadata:
  file_format: 1
