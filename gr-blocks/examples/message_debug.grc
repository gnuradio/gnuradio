options:
  parameters:
    author: Marcus Müller
    copyright: '2022'
    generate_options: no_gui
    id: message_debug_demo
    output_language: python
    title: 'Message Debug: Different log levels'
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: critical
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.mp("TEST")
    period: '2500'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '10000'
    msg: pmt.mp("rare event")
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    name: Throughput
    type: complex
  states: {}

connections:
- [blocks_message_strobe_1, strobe, blocks_message_debug_0, log]
- [blocks_message_strobe_random_0, strobe, blocks_message_debug_0_0, log]
- [blocks_null_source_0, '0', blocks_probe_rate_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-191-gf7b9efd3
