options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: file_metadata_vector_source
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: /tmp/metadat_vector.out
    repeat: 'False'
    type: complex
    vlen: '10'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/received_data.out
    type: complex
    vlen: '10'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Test
    type: complex
    vlen: '10'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '10'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '10'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: green
    marker1: '1'
    marker2: '1'
    name: QT GUI Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_meta_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle2_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle2_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
