options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: file_metadata_sink
    output_language: python
  states: {}

blocks:
- name: qt_samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Orientation.Horizontal
    start: '200000'
    step: '200000'
    stop: '5000000'
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: /tmp/metadat_file.out
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '20000000'
    type: complex
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: 98.9e6
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: addr=192.168.11.2
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: qt_samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_meta_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
