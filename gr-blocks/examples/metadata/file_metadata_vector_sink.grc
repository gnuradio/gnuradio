options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: file_metadata_vector_sink
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: /tmp/metadat_vector.out
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    vlen: '10'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10010000'
    type: complex
    vlen: '10'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 10*[0,1,2,3,4,5,6,7,8,9]
    vlen: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
