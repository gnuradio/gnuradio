options:
  parameters:
    author: Josh Morman
    copyright: Copyright 2020
    description: Show simple examples of Python Snippets inserted into flowgraph
    generate_options: qt_gui
    id: snippets_demo
    output_language: python
    title: Python Snippets Example Flowgraph
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: foo_mod
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      def add(a,b):
          return a+b
  states: {}
- name: head_block
  id: blocks_head
  parameters:
    num_items: '12'
    type: float
  states: {}
- name: s0
  id: snippet
  parameters:
    code: |-
      s = 'After start - 500 priority'
      print(s)
    priority: '500'
    section: main_after_start
  states: {}
- name: s1
  id: snippet
  parameters:
    code: |-
      s = 'After start - 200 priority'
      print(s)
    priority: '200'
    section: main_after_start
  states: {}
- name: s2
  id: snippet
  parameters:
    code: |-
      s = 'After start - negative priority'
      print(s)
    priority: '-400'
    section: main_after_start
  states: {}
- name: s3
  id: snippet
  parameters:
    code: |-
      s = 'After start - 0 priority'
      print(s)
    section: main_after_start
  states: {}
- name: s4
  id: snippet
  parameters:
    code: |-
      s = 'After Init - 100 priority'
      print(s)
    priority: '100'
    section: main_after_init
  states: {}
- name: s5
  id: snippet
  parameters:
    code: |-
      x = 4
      y = foo_mod.add(x,x)
      print(y)
      s = 'After init - 200 priority'
      print(s)
    comment: |-
      This snippet shows how to call a 
      method from an embedded python 
      module
    priority: '200'
    section: main_after_init
  states: {}
- name: s6
  id: snippet
  parameters:
    code: |-
      s = 'After Stop - 500 priority'
      print(s)
    priority: '500'
    section: main_after_stop
  states: {}
- name: s7
  id: snippet
  parameters:
    code: |-
      s = 'After Stop - 200 priority'
      print(s)
      print(self.vsink.data())
    comment: |-
      This snippet shows an example of calling
      a method on another block from within the
      flowgraph - (use at your own risk)
    priority: '200'
    section: main_after_stop
  states: {}
- name: vsink
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {}
- name: vsrc
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: list(range(10))
  states: {}

connections:
- [blocks_throttle2_0, '0', head_block, '0']
- [head_block, '0', vsink, '0']
- [vsrc, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
