options:
  parameters:
    author: Martin Braun
    category: Custom
    description: A demonstration of multiply_matrix_ff to demonstrate how to use it for stream selection
    generate_options: qt_gui
    id: matrix_multiply_demo
    output_language: python
    title: Matrix Multiply/Multiplex Demo
  states: {}

blocks:
- name: new_A
  id: variable_qtgui_chooser
  parameters:
    label: Mode
    label0: Default
    label1: Flip
    label2: Mix
    num_opts: '3'
    option0: ((1, 0), (0, 1))
    option1: ((0, 1), (1, 0))
    option2: ((.5, .5), (.5, .5))
    type: raw
    value: ((1, 0), (0, 1))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt(new_A)
    period: '1000'
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    bus_conns: '[[0,],]'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '100'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    label1: ''
    name: QT GUI Plot
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    label1: ''
    name: QT GUI Plot
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_message_strobe_0, strobe, blocks_multiply_matrix_xx_0, set_A]
- [blocks_multiply_matrix_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_matrix_xx_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_null_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_multiply_matrix_xx_0, '1']

metadata:
  file_format: 1
