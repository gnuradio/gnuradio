options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: pfb_sync_test_qt
    output_language: python
  states: {}

blocks:
- name: amps
  id: variable
  parameters:
    value: '[1]'
  states: {}
- name: graymap
  id: variable
  parameters:
    value: '[[3,1,0,2]]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    orient: Qt.Orientation.Horizontal
    start: '0.0001'
    step: '0.01'
    stop: '2'
    value: '0.050'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: Phase
    orient: Qt.Orientation.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: cmath.exp(1j*phase)
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28/100.0
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*3.14/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(nfilts, nfilts,1.0/sps, 0.35, int(22*sps*nfilts))
    type: ccf
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: sps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import random, math, cmath
  states: {}
- name: phase_probe2
  id: blocks_ctrlport_probe2_c
  parameters:
    desc: Constellation Points
    disp_mask: gr.DISPTIME
    len: '1024'
    name: phase locked
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: '"received signal"'
    label2: '"synced signal"'
    name: ''
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: received_probe2
  id: blocks_ctrlport_probe2_c
  parameters:
    desc: Constellation Points
    disp_mask: gr.DISPTIME
    len: '1024'
    name: received
  states: {}
- name: time_probe2
  id: blocks_ctrlport_probe2_c
  parameters:
    desc: Constellation Points
    disp_mask: gr.DISPTIME
    len: '1024'
    name: time locked
  states: {}

connections:
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_psk_mod_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', received_probe2, '0']
- [digital_costas_loop_cc_0, '0', phase_probe2, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', time_probe2, '0']
- [digital_psk_mod_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
