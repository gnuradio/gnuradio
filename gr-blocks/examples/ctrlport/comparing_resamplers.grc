options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: comparing_resamplers
    output_language: python
  states: {}

blocks:
- name: resamp_rate
  id: variable
  parameters:
    value: '1.25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/10
    offset: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '[1,]'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resamp_rate
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '60'
    nfilts: '32'
    rrate: resamp_rate
    type: ccf
  states: {}
- name: probe_arc_resamp
  id: blocks_ctrlport_probe2_c
  parameters:
    desc: PFB Arbitrary Resampler
    disp_mask: gr.DISPTIME
    len: '1024'
    name: arb_resampler
  states: {}
- name: probe_frac_resamp
  id: blocks_ctrlport_probe2_c
  parameters:
    desc: Fractional Resampler
    disp_mask: gr.DISPTIME
    len: '1024'
    name: mmse_resamp
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', mmse_resampler_xx_0, '0']
- [channels_channel_model_0, '0', pfb_arb_resampler_xxx_0, '0']
- [mmse_resampler_xx_0, '0', probe_frac_resamp, '0']
- [pfb_arb_resampler_xxx_0, '0', probe_arc_resamp, '0']

metadata:
  file_format: 1
