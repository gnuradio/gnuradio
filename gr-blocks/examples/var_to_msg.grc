options:
  parameters:
    generate_options: qt_gui
    id: var_to_msg
    output_language: python
    title: Test Var To Msg
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: test
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Test Variable
    type: int
    value: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: test
    target: test
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
