options:
  parameters:
    author: Marcus Müller
    comment: |-
      Run as
      mic_to_OPUS.py -o myrecording.ogg
    copyright: '2022'
    description: This non-GUI flowgraph illustrates how to save a recording from a microphone to a compressed audio file (.ogg containing OPUS-compressed audio)
    generate_options: no_gui
    id: mic_to_OPUS
    output_language: python
    title: Microphone To OPUS
  states: {}

blocks:
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: device
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample3: FORMAT_OPUS
    file: out_file
    format: FORMAT_OGG
    samp_rate: samp_rate
  states: {}
- name: device
  id: parameter
  parameters:
    comment: |-
      Leaving this empty
      will use the default
      audio device.
      (so, if in doubt, don't
      specify -d)
    label: Audio Device
    short_id: d
    type: str
    value: ''
  states: {}
- name: out_file
  id: parameter
  parameters:
    label: Output File
    short_id: o
    type: str
    value: outfile.ogg
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    comment: |-
      48000 (Hz) is a 
      supported by most
      systems. It's also one
      of the rates that OPUS
      supports.
      Recommendation: leave
      at the default.
    label: Sampling Rate
    short_id: r
    type: intx
    value: '48000'
  states: {}

connections:
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-157-gcf1b4cad
