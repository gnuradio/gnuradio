options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_tag_prop
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: tag0
  id: variable_tag_object
  parameters:
    key: pmt.intern("mark")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.PMT_T
  states: {}
- name: blocks_test_tag_variable_rate_ff_0
  id: blocks_test_tag_variable_rate_ff
  parameters:
    once: 'False'
    step: '0.001'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag0, ]'
    type: float
    vector: numpy.arange(-1, 1, 0.01)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[tag0, ]'
    type: float
    vector: numpy.arange(-1, 1, 0.1)
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 0,0,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    size: '500'
    srate: '1'
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    gui_hint: 1,0,1,1
    label1: ''
    legend: 'False'
    marker1: '0'
    size: '500'
    srate: '1'
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_test_tag_variable_rate_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_test_tag_variable_rate_ff_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
