<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sccc1</value></param>
<param><key>title</key><value>Serially Concatenated Convolutional Code</value></param>
<param><key>author</key><value>AA</value></param>
<param><key>description</key><value>gnuradio flow graph</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noisevar</value></param>
<param><key>value</key><value>10**(-snr_db/10)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/n/harrisville/x/anastas/gnuradio_trunk/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>snr_db</value></param>
<param><key>label</key><value>SNR (dB)</value></param>
<param><key>value</key><value>5</value></param>
<param><key>min</key><value>-10</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_2_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_short_to_float</key>
<param><key>id</key><value>gr_short_to_float_1_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_3_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>BER</value></param>
<param><key>units</key><value>BER</value></param>
<param><key>samp_rate</key><value>R</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>1.0</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>6</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.001</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>R</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>random_source_x</key>
<param><key>id</key><value>random_source_x_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>trellis_pccc_encoder_xx</key>
<param><key>id</key><value>trellis_pccc_encoder_xx_0</value></param>
<param><key>type</key><value>ss</value></param>
<param><key>o_fsm_args</key><value>prefix+"gr-trellis/src/examples/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>i_fsm_args</key><value>prefix+"gr-trellis/src/examples/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>interleaver_args</key><value>trellis.interleaver(block,666)</value></param>
<param><key>bl</key><value>block</value></param>
</block>
<block>
<key>trellis_pccc_decoder_x</key>
<param><key>id</key><value>trellis_pccc_decoder_x_0</value></param>
<param><key>out_type</key><value>s</value></param>
<param><key>o_fsm_args</key><value>prefix+"gr-trellis/src/examples/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>o_final_state</key><value>-1</value></param>
<param><key>i_fsm_args</key><value>prefix+"gr-trellis/src/examples/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>i_final_state</key><value>-1</value></param>
<param><key>interleaver</key><value>trellis.interleaver(block,666)</value></param>
<param><key>block_size</key><value>block</value></param>
<param><key>iterations</key><value>10</value></param>
<param><key>siso_type</key><value>trellis.TRELLIS_MIN_SUM</value></param>
</block>
<block>
<key>trellis_metrics_x</key>
<param><key>id</key><value>trellis_metrics_x_0</value></param>
<param><key>type</key><value>f</value></param>
<param><key>card</key><value>16</value></param>
<param><key>dim</key><value>2</value></param>
<param><key>table</key><value>-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7,0,   0,-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>samples_per_second</key><value>R</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>short</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>-7,0,-5,0,-3,0,-1,0,1,0,3,0,5,0,7,0,-7,0,-5,0,-3,0,-1,0,1,0,3,0,5,0,7</value></param>
<param><key>dimension</key><value>2</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noisevar</value></param>
<param><key>seed</key><value>-42</value></param>
</block>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_2_0</source_block_id><sink_block_id>gr_short_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_short_to_float_1_0</source_block_id><sink_block_id>wxgui_numbersink2_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_multiply_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_multiply_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_add_xx_1</source_block_id><sink_block_id>trellis_metrics_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>random_source_x_0</source_block_id><sink_block_id>trellis_pccc_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_pccc_encoder_xx_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_metrics_x_0</source_block_id><sink_block_id>trellis_pccc_decoder_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_pccc_decoder_x_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>gr_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
