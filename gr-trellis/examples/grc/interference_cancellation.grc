options:
  parameters:
    author: AA
    category: Custom
    description: gnuradio flow graph
    generate_options: qt_gui
    id: int_cancellation
    output_language: python
    title: Superposition Coding
  states: {}

blocks:
- name: R
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    label: P1/P
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.1'
  states: {}
- name: block
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fsm1
  id: variable
  parameters:
    value: '"awgn1o2_16.fsm"'
  states: {}
- name: fsm2
  id: variable
  parameters:
    value: '"awgn1o2_4.fsm"'
  states: {}
- name: noisevar
  id: variable
  parameters:
    value: 10**(-snr_db/10)
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"@FSM_FILE_INSTALL_DIR@"'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: P/sigma^2 (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisevar
    noise_type: analog.GR_GAUSSIAN
    seed: '-42'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: block
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: block
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: alpha**0.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: (1-alpha)**0.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: alpha**0.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (1-alpha)**0.5
    type: complex
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: R
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: 1,1j,-1j,-1
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: 1,1j,-1j,-1
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: 1,1j,-1j,-1
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: 1,1j,-1j,-1
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_1
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_2
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: BER
    min: '0'
    name: '"BER1 (Raw)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,1,1,1
    label1: BER
    min: '0'
    name: '"BER 2 (Raw)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,1,1
    label1: BER
    min: '0'
    name: '"BER 2 (after cancelling user 1)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    label1: BER
    min: '0'
    name: BER 1 (after cancelling user 2)
    type: float
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: prefix+fsm1
    init_state: '0'
    type: bb
  states: {}
- name: trellis_encoder_xx_1
  id: trellis_encoder_xx
  parameters:
    fsm_args: prefix+fsm2
    init_state: '0'
    type: bb
  states: {}
- name: trellis_encoder_xx_2
  id: trellis_encoder_xx
  parameters:
    fsm_args: prefix+fsm1
    init_state: '0'
    type: bb
  states: {}
- name: trellis_encoder_xx_2_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: prefix+fsm2
    init_state: '0'
    type: bb
  states: {}
- name: trellis_viterbi_combined_xx_0
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: block
    dim: '1'
    final_state: '-1'
    fsm_args: prefix+fsm2
    init_state: '-1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: (1-alpha)**0.5*1,(1-alpha)**0.5*1j,(1-alpha)**0.5*(-1j),(1-alpha)**0.5*(-1)
    type: c
  states: {}
- name: trellis_viterbi_combined_xx_0_0
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: block
    dim: '1'
    final_state: '-1'
    fsm_args: prefix+fsm1
    init_state: '-1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: alpha**0.5*1,alpha**0.5*1j,alpha**0.5*(-1j),alpha**0.5*(-1)
    type: c
  states: {}
- name: trellis_viterbi_combined_xx_1
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: block
    dim: '1'
    final_state: '-1'
    fsm_args: prefix+fsm1
    init_state: '-1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: alpha**0.5*1,alpha**0.5*1j,alpha**0.5*(-1j),alpha**0.5*(-1)
    type: c
  states: {}
- name: trellis_viterbi_combined_xx_2
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: block
    dim: '1'
    final_state: '-1'
    fsm_args: prefix+fsm2
    init_state: '-1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: (1-alpha)**0.5*1,(1-alpha)**0.5*1j,(1-alpha)**0.5*(-1j),(1-alpha)**0.5*(-1)
    type: c
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: user1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: user2
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: observation
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: user1_est
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: user2_est
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: user1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: user1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: user1_est
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: user2_est
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: user2
  states: {}
- name: virtual_source_0_4
  id: virtual_source
  parameters:
    stream_id: user2
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_random_source_x_0, '0', trellis_encoder_xx_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0, '0']
- [analog_random_source_x_1, '0', trellis_encoder_xx_1, '0']
- [analog_random_source_x_1, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_sub_xx_2, '1']
- [blocks_multiply_const_vxx_2_0, '0', blocks_sub_xx_2_0, '1']
- [blocks_sub_xx_2, '0', trellis_viterbi_combined_xx_0, '0']
- [blocks_sub_xx_2_0, '0', trellis_viterbi_combined_xx_0_0, '0']
- [blocks_throttle_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [digital_chunks_to_symbols_xx_0_0_1, '0', blocks_multiply_const_vxx_2_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [fec_ber_bf_0_1, '0', qtgui_number_sink_0_0, '0']
- [fec_ber_bf_0_2, '0', qtgui_number_sink_0, '0']
- [trellis_encoder_xx_0, '0', blocks_throttle_0, '0']
- [trellis_encoder_xx_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [trellis_encoder_xx_2, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [trellis_encoder_xx_2_0, '0', digital_chunks_to_symbols_xx_0_0_1, '0']
- [trellis_viterbi_combined_xx_0, '0', fec_ber_bf_0_0, '0']
- [trellis_viterbi_combined_xx_0_0, '0', fec_ber_bf_0, '0']
- [trellis_viterbi_combined_xx_1, '0', fec_ber_bf_0_2, '0']
- [trellis_viterbi_combined_xx_1, '0', virtual_sink_0_2, '0']
- [trellis_viterbi_combined_xx_2, '0', fec_ber_bf_0_1, '0']
- [trellis_viterbi_combined_xx_2, '0', virtual_sink_0_2_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0_2, '1']
- [virtual_source_0_0, '0', fec_ber_bf_0, '1']
- [virtual_source_0_1, '0', trellis_viterbi_combined_xx_1, '0']
- [virtual_source_0_1_0, '0', trellis_viterbi_combined_xx_2, '0']
- [virtual_source_0_1_1, '0', blocks_sub_xx_2, '0']
- [virtual_source_0_1_2, '0', blocks_sub_xx_2_0, '0']
- [virtual_source_0_2, '0', trellis_encoder_xx_2, '0']
- [virtual_source_0_2_0, '0', trellis_encoder_xx_2_0, '0']
- [virtual_source_0_3, '0', fec_ber_bf_0_1, '1']
- [virtual_source_0_4, '0', fec_ber_bf_0_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-689-g85dee02b
