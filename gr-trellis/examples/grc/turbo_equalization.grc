options:
  parameters:
    author: AA
    category: Custom
    description: gnuradio flow graph
    generate_options: qt_gui
    id: turbo_equalization
    output_language: python
    title: Hard/Soft/Turbo Equalization
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: numpy.mean((numpy.square(numpy.abs(tot_mod[1]))))
  states: {}
- name: EsN0_dB
  id: variable_qtgui_range
  parameters:
    label: Es/N0 (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-10'
    step: '1'
    stop: '20'
    value: '2'
  states: {}
- name: R
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: block_b
  id: variable
  parameters:
    value: bpsym*1000
  states: {}
- name: bpsym
  id: variable
  parameters:
    value: int(round(math.log(fsm_o.I())/math.log(2)))
  states: {}
- name: channel
  id: variable
  parameters:
    value: fu.c_channel
  states: {}
- name: fsm_i
  id: variable
  parameters:
    value: trellis.fsm(len(modulation[1]),len(channel))
  states: {}
- name: fsm_o
  id: variable
  parameters:
    value: trellis.fsm(prefix+"/awgn1o2_4.fsm")
  states: {}
- name: interleaver
  id: variable
  parameters:
    value: trellis.interleaver(block_b/bpsym,666)
  states: {}
- name: modulation
  id: variable
  parameters:
    value: fu.pam4
  states: {}
- name: noisevar
  id: variable
  parameters:
    value: 10**(-EsN0_dB/10.0)  * Es   /2.0
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"@FSM_FILE_INSTALL_DIR@"'
  states: {}
- name: tot_mod
  id: variable
  parameters:
    value: fu.make_isi_lookup(modulation,channel,False)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisevar**0.5
    noise_type: analog.GR_GAUSSIAN
    seed: '-42'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1007'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: bpsym
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: R
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bpsym
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bpsym
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bpsym
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: modulation[0]
    in_type: byte
    out_type: float
    symbol_table: modulation[1]
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_1
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fu.c_channel
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import gnuradio.trellis.fsm_utils as fu
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: This is the simplest hard Viterbi equalizer/hard Viterbi decoder
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: This is a better soft-equalizer/Viterbi decoder
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: This is the full-fledged turbo equalizer/decoder
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"BER (Hard)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"BER (Soft)"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"BER (Turbo)"'
    type: float
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: fsm_o
    init_state: '0'
    type: bb
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver.k()
    syms_per_block: '1'
    table: interleaver.interleaver_indices()
    type: byte
  states: {}
- name: trellis_permutation_0_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver.k()
    syms_per_block: '1'
    table: interleaver.deinterleaver_indices()
    type: byte
  states: {}
- name: trellis_permutation_0_0_0
  id: trellis_permutation
  parameters:
    interleaver_size: interleaver.k()
    syms_per_block: fsm_o.O()
    table: interleaver.deinterleaver_indices()
    type: float
  states: {}
- name: trellis_sccc_decoder_combined_xx_0
  id: trellis_sccc_decoder_combined_xx
  parameters:
    block_size: interleaver.k()
    dim: tot_mod[0]
    i_final_state: '-1'
    i_fsm_args: fsm_i
    i_init_state: '-1'
    interleaver: interleaver
    iterations: '5'
    metric_type: digital.TRELLIS_EUCLIDEAN
    o_final_state: '-1'
    o_fsm_args: fsm_o
    o_init_state: '-1'
    out_type: b
    scaling: '1.0'
    siso_type: trellis.TRELLIS_MIN_SUM
    table: tot_mod[1]
    type: f
  states: {}
- name: trellis_siso_combined_f_0
  id: trellis_siso_combined_f
  parameters:
    a_post_in: 'True'
    a_post_out: 'False'
    block_size: interleaver.k()
    dim: tot_mod[0]
    final_state: '-1'
    fsm_args: fsm_i
    init_state: '-1'
    metric_type: trellis.TRELLIS_EUCLIDEAN
    siso_type: trellis.TRELLIS_MIN_SUM
    table: tot_mod[1]
  states: {}
- name: trellis_viterbi_combined_xx_0
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: interleaver.k()
    dim: tot_mod[0]
    final_state: '-1'
    fsm_args: fsm_i
    init_state: '-1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: tot_mod[1]
    type: f
  states: {}
- name: trellis_viterbi_combined_xx_1
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: interleaver.k()
    dim: '1'
    final_state: '-1'
    fsm_args: fsm_o
    init_state: '-1'
    metric_type: digital.TRELLIS_HARD_SYMBOL
    out_type: b
    table: 0,1,2,3
    type: f
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: interleaver.k()
    final_state: '-1'
    fsm_args: fsm_o
    init_state: '0'
    type: b
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: observation
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: info
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: info_i
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: estimate_i
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: estimate1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: estimate1
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: info
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: info
  states: {}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: info
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}

connections:
- [analog_const_source_x_0, '0', trellis_siso_combined_f_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', trellis_viterbi_combined_xx_1, '0']
- [blocks_pack_k_bits_bb_0, '0', trellis_encoder_xx_0, '0']
- [blocks_throttle_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_ber_bf_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_0_1_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', fec_ber_bf_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', fir_filter_xxx_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [fec_ber_bf_0_1, '0', qtgui_number_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_1, '0']
- [trellis_encoder_xx_0, '0', trellis_permutation_0, '0']
- [trellis_encoder_xx_0, '0', virtual_sink_0_0_0, '0']
- [trellis_permutation_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [trellis_permutation_0_0, '0', blocks_char_to_float_0, '0']
- [trellis_permutation_0_0, '0', virtual_sink_0_1_0, '0']
- [trellis_permutation_0_0_0, '0', trellis_viterbi_x_0, '0']
- [trellis_sccc_decoder_combined_xx_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [trellis_siso_combined_f_0, '0', trellis_permutation_0_0_0, '0']
- [trellis_viterbi_combined_xx_0, '0', trellis_permutation_0_0, '0']
- [trellis_viterbi_combined_xx_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [trellis_viterbi_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_0, '0', trellis_viterbi_combined_xx_0, '0']
- [virtual_source_0_0_0_0_0, '0', fec_ber_bf_0, '0']
- [virtual_source_0_0_1, '0', fec_ber_bf_0_1, '1']
- [virtual_source_0_0_1_0, '0', fec_ber_bf_0, '1']
- [virtual_source_0_0_1_0_0, '0', fec_ber_bf_0_0, '1']
- [virtual_source_0_1, '0', trellis_siso_combined_f_0, '1']
- [virtual_source_0_1_0, '0', trellis_sccc_decoder_combined_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-689-g85dee02b
