options:
  parameters:
    author: AA
    category: Custom
    description: gnuradio flow graph
    generate_options: qt_gui
    id: sccc
    output_language: python
    title: Serially Concatenated Convolutional Code
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: sum(numpy.square(constellation))/(len(constellation)/(1.0*dim))
  states: {}
- name: EsN0_dB
  id: variable_qtgui_range
  parameters:
    label: Es/N0 (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-10'
    step: '1'
    stop: '20'
    value: '2'
  states: {}
- name: R
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: block
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: constellation
  id: variable
  parameters:
    value: mod[1]
  states: {}
- name: dim
  id: variable
  parameters:
    value: mod[0]
  states: {}
- name: fsm_i
  id: variable
  parameters:
    value: trellis.fsm(prefix+"/awgn2o3_4.fsm")
  states: {}
- name: fsm_o
  id: variable
  parameters:
    value: trellis.fsm(prefix+"awgn1o2_4.fsm")
  states: {}
- name: interleaver
  id: variable
  parameters:
    value: trellis.interleaver(block,666)
  states: {}
- name: mod
  id: variable
  parameters:
    value: fu.psk2x3
  states: {}
- name: noisevar
  id: variable
  parameters:
    value: 10**(-EsN0_dB/10.0)  * Es   /2.0
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"@FSM_FILE_INSTALL_DIR@"'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisevar**0.5
    noise_type: analog.GR_GAUSSIAN
    seed: '-42'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1007'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: R
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: dim
    in_type: byte
    out_type: float
    symbol_table: constellation
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import gnuradio.trellis.fsm_utils as fu
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"BER"'
    type: float
  states: {}
- name: trellis_sccc_decoder_combined_xx_0
  id: trellis_sccc_decoder_combined_xx
  parameters:
    block_size: block
    dim: dim
    i_final_state: '-1'
    i_fsm_args: fsm_i
    i_init_state: '0'
    interleaver: interleaver
    iterations: '5'
    metric_type: digital.TRELLIS_EUCLIDEAN
    o_final_state: '-1'
    o_fsm_args: fsm_o
    o_init_state: '0'
    out_type: b
    scaling: 1.0/noisevar
    siso_type: trellis.TRELLIS_MIN_SUM
    table: constellation
    type: f
  states: {}
- name: trellis_sccc_encoder_xx_0
  id: trellis_sccc_encoder_xx
  parameters:
    bl: block
    i_fsm_args: fsm_i
    i_init_state: '0'
    interleaver_args: interleaver
    o_fsm_args: fsm_o
    o_init_state: '0'
    type: bb
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: observation
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: info
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: info
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', trellis_sccc_encoder_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [trellis_sccc_decoder_combined_xx_0, '0', fec_ber_bf_0, '0']
- [trellis_sccc_encoder_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0, '0', trellis_sccc_decoder_combined_xx_0, '0']
- [virtual_source_0_0, '0', fec_ber_bf_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-689-g85dee02b
