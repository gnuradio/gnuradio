<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sccc1</value></param>
<param><key>title</key><value>Parallel Concatenated Convolutional Code</value></param>
<param><key>author</key><value>AA</value></param>
<param><key>description</key><value>gnuradio flow graph</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>GNURADIO_SRC_DIR</value></param>
<param><key>value</key><value>"/home/jank/src/gnuradio/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>GNURADIO_SRC_DIR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noisevar</value></param>
<param><key>value</key><value>10**(-snr_db/10)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>samples_per_second</key><value>R</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>noisevar</value></param>
<param><key>seed</key><value>-42</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_2_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_1_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>o_fsm_args</key><value>prefix+"gr-trellis/examples/python/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>i_fsm_args</key><value>prefix+"gr-trellis/examples/python/fsm_files/awgn1o2_4.fsm"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>max</key><value>1</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label1</key><value>BER</value></param>
<param><key>color1</key><value>("black", "black")</value></param>
<param><key>color2</key><value>("black", "black")</value></param>
<param><key>color3</key><value>("black", "black")</value></param>
<param><key>color4</key><value>("black", "black")</value></param>
<param><key>color5</key><value>("black", "black")</value></param>
<param><key>color6</key><value>("black", "black")</value></param>
<param><key>color7</key><value>("black", "black")</value></param>
<param><key>color8</key><value>("black", "black")</value></param>
<param><key>color9</key><value>("black", "black")</value></param>
<param><key>color10</key><value>("black", "black")</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>snr_db</value></param>
<param><key>label</key><value>SNR (dB)</value></param>
<param><key>value</key><value>5</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.001</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>symbol_table</key><value>-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7,0,   0,-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7,0</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>trellis_pccc_decoder_combined_xx</key>
<param><key>id</key><value>trellis_pccc_decoder_combined_xx_0</value></param>
<param><key>type</key><value>f</value></param>
<param><key>out_type</key><value>s</value></param>
<param><key>o_fsm_args</key><value>prefix+"gr-trellis/examples/python/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>o_init_state</key><value>0</value></param>
<param><key>o_final_state</key><value>-1</value></param>
<param><key>i_fsm_args</key><value>prefix+"gr-trellis/examples/python/fsm_files/awgn1o2_4.fsm"</value></param>
<param><key>i_init_state</key><value>0</value></param>
<param><key>i_final_state</key><value>-1</value></param>
<param><key>interleaver</key><value>trellis.interleaver(block,666)</value></param>
<param><key>block_size</key><value>block</value></param>
<param><key>iterations</key><value>10</value></param>
<param><key>dim</key><value>2</value></param>
<param><key>table</key><value>-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7,0,   0,-7,0, -5,0, -3,0, -1,0, 1,0, 3,0, 5,0, 7,0</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
<param><key>siso_type</key><value>trellis.TRELLIS_MIN_SUM</value></param>
<param><key>scaling</key><value>1.0</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>trellis_pccc_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>trellis_pccc_decoder_combined_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_pccc_encoder_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_1_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_pccc_decoder_combined_xx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_2_0</source_block_id><sink_block_id>blocks_short_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
