options:
  parameters:
    author: AA
    category: Custom
    description: gnuradio flow graph
    generate_options: qt_gui
    id: pccc
    output_language: python
    title: Parallel Concatenated Convolutional Code
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: sum(numpy.square(constellation))/(len(constellation)/(1.0*dim))
  states: {}
- name: EsN0_dB
  id: variable_qtgui_range
  parameters:
    label: Es/N0 (dB)
    orient: QtCore.Qt.Orientation.Horizontal
    start: '-10'
    step: '1'
    stop: '20'
    value: '2'
  states: {}
- name: R
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: block
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: constellation
  id: variable
  parameters:
    value: mod[1]
  states: {}
- name: constellation
  id: variable
  parameters:
    value: '-3,-3,-1,-3,1,-3,3,-3,   -3,-1,-1,-1,1,-1,3,-1,     -3,1,-1,1,1,1,3,1,     -3,3,-1,3,1,3,3,3        '
  states: {state: disabled}
- name: dim
  id: variable
  parameters:
    value: mod[0]
  states: {}
- name: dim
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: fsm1
  id: variable
  parameters:
    value: trellis.fsm(prefix+"awgn1o2_4rsc.fsm")
  states: {}
- name: fsm2
  id: variable
  parameters:
    value: trellis.fsm(prefix+"awgn1o1_4rsc.fsm")
  states: {}
- name: interleaver
  id: variable
  parameters:
    value: trellis.interleaver(block,666)
  states: {}
- name: mod
  id: variable
  parameters:
    value: fu.psk2x3
  states: {}
- name: noisevar
  id: variable
  parameters:
    value: 10**(-EsN0_dB/10.0)  * Es   /2.0
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"@FSM_FILE_INSTALL_DIR@"'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisevar**0.5
    noise_type: analog.GR_GAUSSIAN
    seed: '-42'
    type: float
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: block
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: R
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: dim
    in_type: byte
    out_type: float
    symbol_table: constellation
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import gnuradio.trellis.fsm_utils as fu
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    min: '0'
    name: '"BER"'
    type: float
  states: {}
- name: trellis_pccc_decoder_combined_xx_0
  id: trellis_pccc_decoder_combined_xx
  parameters:
    block_size: block
    dim: dim
    i_final_state: '-1'
    i_fsm_args: fsm2
    i_init_state: '0'
    interleaver: interleaver
    iterations: '10'
    metric_type: digital.TRELLIS_EUCLIDEAN
    o_final_state: '-1'
    o_fsm_args: fsm1
    o_init_state: '0'
    out_type: b
    scaling: 0.5/noisevar
    siso_type: trellis.TRELLIS_MIN_SUM
    table: constellation
    type: f
  states: {}
- name: trellis_pccc_encoder_xx_0
  id: trellis_pccc_encoder_xx
  parameters:
    bl: block
    i_fsm_args: fsm2
    i_init_state: '0'
    interleaver_args: interleaver
    o_fsm_args: fsm1
    o_init_state: '0'
    type: bb
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: observation
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: info
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: estimate
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: observation
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: info
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: estimate
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [analog_random_source_x_0_0, '0', virtual_sink_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0, '0']
- [blocks_throttle_0_0, '0', trellis_pccc_encoder_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_add_xx_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [trellis_pccc_decoder_combined_xx_0, '0', virtual_sink_0_1, '0']
- [trellis_pccc_encoder_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0, '0', trellis_pccc_decoder_combined_xx_0, '0']
- [virtual_source_0_0, '0', fec_ber_bf_0, '0']
- [virtual_source_0_0_0, '0', fec_ber_bf_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-689-g85dee02b
