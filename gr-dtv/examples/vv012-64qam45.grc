options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: vv012_64qam45
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: vv.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/vv012-64qam45.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: 8192 // 32
    input_size: '8192'
    tagname: ''
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    inband: INBAND_OFF
    mode: INPUTMODE_HIEFF
    rate1: C4_5
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C4_5
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C4_5
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C4_5
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvbt2_cellinterleaver_cc_0
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    constellation: MOD_64QAM
    fecblocks: '151'
    framesize: FECFRAME_NORMAL
    tiblocks: '3'
  states: {}
- name: dtv_dvbt2_framemapper_cc_0
  id: dtv_dvbt2_framemapper_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    constellation: MOD_64QAM
    fecblocks: '151'
    fftsize1: FFTSIZE_8K
    framesize: FECFRAME_NORMAL
    guardinterval: GI_1_32
    l1constellation: L1_MOD_64QAM
    numdatasyms: '242'
    paprmode1: PAPR_TR
    pilotpattern: PILOT_PP7
    preamble1: PREAMBLE_T2_SISO
    rate: C4_5
    rotation: ROTATION_ON
    t2frames: '2'
    tiblocks: '3'
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_freqinterleaver_cc_0
  id: dtv_dvbt2_freqinterleaver_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_8K
    guardinterval: GI_1_32
    numdatasyms: '242'
    paprmode1: PAPR_TR
    pilotpattern: PILOT_PP7
    preamble1: PREAMBLE_T2_SISO
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_interleaver_bb_0
  id: dtv_dvbt2_interleaver_bb
  parameters:
    constellation: MOD_64QAM
    framesize: FECFRAME_NORMAL
    rate: C4_5
  states: {}
- name: dtv_dvbt2_modulator_bc_0
  id: dtv_dvbt2_modulator_bc
  parameters:
    constellation: MOD_64QAM
    framesize: FECFRAME_NORMAL
    rotation: ROTATION_ON
  states: {}
- name: dtv_dvbt2_p1insertion_cc_0
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_8K
    guardinterval: GI_1_32
    numdatasyms: '242'
    preamble1: PREAMBLE_T2_SISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_paprtr_cc_0
  id: dtv_dvbt2_paprtr_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_8K
    guardinterval: GI_1_32
    iterations: '50'
    numdatasyms: '242'
    paprmode1: PAPR_TR
    pilotpattern: PILOT_PP7
    vclip: '2.57'
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_pilotgenerator_cc_0
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    bandwidth: BANDWIDTH_8_0_MHZ
    carriermode: CARRIERS_EXTENDED
    equalization: EQUALIZATION_OFF
    fftsize: FFTSIZE_8K
    guardinterval: GI_1_32
    numdatasyms: '242'
    paprmode1: PAPR_TR
    pilotpattern: PILOT_PP7
    preamble1: PREAMBLE_T2_SISO
    version: VERSION_111
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, 4000000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: freqint-pilotgen
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ldpc-bitint
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: freqint-pilotgen
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ldpc-bitint
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', dtv_dvbt2_p1insertion_cc_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', virtual_sink_1, '0']
- [dtv_dvbt2_cellinterleaver_cc_0, '0', dtv_dvbt2_framemapper_cc_0, '0']
- [dtv_dvbt2_framemapper_cc_0, '0', dtv_dvbt2_freqinterleaver_cc_0, '0']
- [dtv_dvbt2_freqinterleaver_cc_0, '0', virtual_sink_0, '0']
- [dtv_dvbt2_interleaver_bb_0, '0', dtv_dvbt2_modulator_bc_0, '0']
- [dtv_dvbt2_modulator_bc_0, '0', dtv_dvbt2_cellinterleaver_cc_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_file_sink_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [dtv_dvbt2_paprtr_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [dtv_dvbt2_pilotgenerator_cc_0, '0', dtv_dvbt2_paprtr_cc_0, '0']
- [virtual_source_0, '0', dtv_dvbt2_pilotgenerator_cc_0, '0']
- [virtual_source_1, '0', dtv_dvbt2_interleaver_bb_0, '0']

metadata:
  file_format: 1
