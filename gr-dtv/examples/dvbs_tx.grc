options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1280e6
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: adv.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/advdvbs78.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_ON
    rate1: C1_4
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C7_8
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '1512'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, 0.35, rrc_taps)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, ((symbol_rate * 1.35) / 2 ) + 1e5)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*2)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: inner-mod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: int-inner
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: inner-mod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: int-inner
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', fft_filter_xxx_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', virtual_sink_1, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', blocks_vector_to_stream_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [fft_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [virtual_source_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [virtual_source_1, '0', dtv_dvbt_inner_coder_0, '0']

metadata:
  file_format: 1
