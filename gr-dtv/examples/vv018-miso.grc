options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: vv018_miso
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0) * 8 / 7
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.5'
    stop: '89'
    value: '50'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: vvtx1.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: vvtx2.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/vv018-miso.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.2'
    type: complex
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: 32768 // 16
    input_size: '32768'
    tagname: ''
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: 32768 // 16
    input_size: '32768'
    tagname: ''
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    inband: INBAND_OFF
    mode: INPUTMODE_HIEFF
    rate1: C5_6
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C5_6
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C5_6
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    rate1: C5_6
    standard: STANDARD_DVBT2
  states: {}
- name: dtv_dvbt2_cellinterleaver_cc_0
  id: dtv_dvbt2_cellinterleaver_cc
  parameters:
    constellation: MOD_256QAM
    fecblocks: '61'
    framesize: FECFRAME_NORMAL
    tiblocks: '1'
  states: {}
- name: dtv_dvbt2_framemapper_cc_0
  id: dtv_dvbt2_framemapper_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    constellation: MOD_256QAM
    fecblocks: '61'
    fftsize1: FFTSIZE_32K
    framesize: FECFRAME_NORMAL
    guardinterval: GI_1_16
    l1constellation: L1_MOD_64QAM
    numdatasyms: '19'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_MISO
    rate: C5_6
    rotation: ROTATION_ON
    t2frames: '2'
    tiblocks: '1'
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_freqinterleaver_cc_0
  id: dtv_dvbt2_freqinterleaver_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K
    guardinterval: GI_1_16
    numdatasyms: '19'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_MISO
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_interleaver_bb_0
  id: dtv_dvbt2_interleaver_bb
  parameters:
    constellation: MOD_256QAM
    framesize: FECFRAME_NORMAL
    rate: C5_6
  states: {}
- name: dtv_dvbt2_miso_cc_0
  id: dtv_dvbt2_miso_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize: FFTSIZE_32K
    guardinterval: GI_1_16
    numdatasyms: '19'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_modulator_bc_0
  id: dtv_dvbt2_modulator_bc
  parameters:
    constellation: MOD_256QAM
    framesize: FECFRAME_NORMAL
    rotation: ROTATION_ON
  states: {}
- name: dtv_dvbt2_p1insertion_cc_0
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K
    guardinterval: GI_1_16
    numdatasyms: '19'
    preamble1: PREAMBLE_T2_MISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_p1insertion_cc_0_0
  id: dtv_dvbt2_p1insertion_cc
  parameters:
    carriermode: CARRIERS_EXTENDED
    fftsize1: FFTSIZE_32K
    guardinterval: GI_1_16
    numdatasyms: '19'
    preamble1: PREAMBLE_T2_MISO
    showlevels: SHOWLEVELS_OFF
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_pilotgenerator_cc_0
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    bandwidth: BANDWIDTH_8_0_MHZ
    carriermode: CARRIERS_EXTENDED
    equalization: EQUALIZATION_OFF
    fftsize: FFTSIZE_32K
    guardinterval: GI_1_16
    misogroup: MISO_TX2
    numdatasyms: '19'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_MISO
    version: VERSION_111
  states: {}
- name: dtv_dvbt2_pilotgenerator_cc_1
  id: dtv_dvbt2_pilotgenerator_cc
  parameters:
    bandwidth: BANDWIDTH_8_0_MHZ
    carriermode: CARRIERS_EXTENDED
    equalization: EQUALIZATION_OFF
    fftsize: FFTSIZE_32K
    guardinterval: GI_1_16
    misogroup: MISO_TX1
    numdatasyms: '19'
    paprmode1: PAPR_OFF
    pilotpattern: PILOT_PP2
    preamble1: PREAMBLE_T2_MISO
    version: VERSION_111
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: '8000000'
    center_freq0: center_freq
    center_freq1: '0'
    gain0: tx_gain
    nchan: '2'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    ant1: ''
    center_freq0: uhd.tune_request(center_freq, 4000000)
    center_freq1: uhd.tune_request(center_freq, 4000000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=128,master_clock_rate=" + str(samp_rate*2)'
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_multiply_const_xx_0, '0', soapy_custom_sink_0, '1']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '1']
- [blocks_multiply_const_xx_0_0, '0', soapy_custom_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', uhd_usrp_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', dtv_dvbt2_p1insertion_cc_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', dtv_dvbt2_p1insertion_cc_0_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbt2_interleaver_bb_0, '0']
- [dtv_dvbt2_cellinterleaver_cc_0, '0', dtv_dvbt2_framemapper_cc_0, '0']
- [dtv_dvbt2_framemapper_cc_0, '0', dtv_dvbt2_freqinterleaver_cc_0, '0']
- [dtv_dvbt2_freqinterleaver_cc_0, '0', dtv_dvbt2_miso_cc_0, '0']
- [dtv_dvbt2_interleaver_bb_0, '0', dtv_dvbt2_modulator_bc_0, '0']
- [dtv_dvbt2_miso_cc_0, '0', dtv_dvbt2_pilotgenerator_cc_1, '0']
- [dtv_dvbt2_miso_cc_0, '1', dtv_dvbt2_pilotgenerator_cc_0, '0']
- [dtv_dvbt2_modulator_bc_0, '0', dtv_dvbt2_cellinterleaver_cc_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_file_sink_0_0, '0']
- [dtv_dvbt2_p1insertion_cc_0, '0', blocks_multiply_const_xx_0, '0']
- [dtv_dvbt2_p1insertion_cc_0_0, '0', blocks_file_sink_0, '0']
- [dtv_dvbt2_p1insertion_cc_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [dtv_dvbt2_pilotgenerator_cc_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [dtv_dvbt2_pilotgenerator_cc_1, '0', digital_ofdm_cyclic_prefixer_0_0, '0']

metadata:
  file_format: 1
