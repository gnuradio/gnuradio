options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_atsc_rx
    output_language: python
    realtime_scheduling: '1'
    title: Receive ATSC from USRP
  states: {}

blocks:
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    comment: Digital Ch 28 - 557 MHz
    gui_hint: 0,0,1,1
    label: Center Frequency
    type: real
    value: (channel*1e6)+3e6
  states: {}
- name: channel
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Channel
    labels: '[''2'', ''3'', ''4'', ''5'', ''6'', ''7'', ''8'', ''9'', ''10'', ''11'', ''12'', ''13'', ''14'', ''15'', ''16'', ''17'', ''18'', ''19'', ''20'', ''21'', ''22'', ''23'', ''24'', ''25'', ''26'', ''27'', ''28'', ''29'', ''30'', ''31'', ''32'', ''33'', ''34'', ''35'', ''36'', ''CATV 57'', ''CATV 58'', ''CATV 59'', ''CATV 60'', ''CATV 61'', ''CATV 143'', ''CATV 144'', ''CATV 145'']'
    num_opts: '0'
    options: |
      [54, 60, 66, 76, 82, 174, 180, 186, 192, 198, 204, 210, 470, 476, 482, 488, 494, 500, 506, 512, 518, 524, 530, 536, 542, 548, 554, 560, 566, 572, 578, 584, 590, 596, 602, 420, 426, 432, 438, 444, 906, 912, 918]
    type: int
    value: '554'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '4.0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/mpeg.live.ts
    type: byte
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    affinity: '1'
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: dtv_atsc_deinterleaver_0
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: dtv_atsc_depad_0
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: dtv_atsc_derandomizer_0
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: dtv_atsc_equalizer_0
  id: dtv_atsc_equalizer
  parameters: {}
  states: {}
- name: dtv_atsc_fpll_0
  id: dtv_atsc_fpll
  parameters:
    affinity: '0'
    comment: Set core affinity for performance
    rate: oversampled_rate
  states: {}
- name: dtv_atsc_fs_checker_0
  id: dtv_atsc_fs_checker
  parameters: {}
  states: {}
- name: dtv_atsc_rs_decoder_0
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: dtv_atsc_sync_0
  id: dtv_atsc_sync
  parameters:
    rate: oversampled_rate
  states: {}
- name: dtv_atsc_viterbi_decoder_0
  id: dtv_atsc_viterbi_decoder
  parameters:
    affinity: '2'
    comment: Set core affinity for performance
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.1152'
    comment: |-
      FFT-based filter is less CPU intensive
      for all but the smallest filter tap lengths.
    decim: '1'
    gain: '1'
    ntaps: '50'
    samp_rate: sample_rate
    sym_rate: atsc_sym_rate/2.0
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Past examples with the RX filter use a pfb arb resampler
      that crushes most CPUs.  This approach is optimally tuned
      and only needs an FFT-based RRC and no resampler 
      for better performance.
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      This flowgraph can be adapted to watch the stream live by
      installing gr-grnet and using a tcp sink in "server" mode.
      You can then use smplayer to play the stream (vlc doesn't
      work as well as it doesn't seem to tolerate stream errors
      well.  In smplayer, under options these non-default settings
      seemed to help with stream viewing:
      - set performance preferences to allow 
        frame drops and hard frame drops.
      - Set hardware decoding to auto.
      - On the cache performance tab Increase stream buffer to 8096.

      NOTE: Be patient with the players if there's errors in the signal.
      On a real TV it may pixelate, but with streaming players they may
      get out of sync and look like they freeze with no video while 
      they're trying to resync with good data.
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    bandwidth0: '6000000'
    center_freq0: center_freq
    gain0: '35'
    samp_rate: sample_rate
    type: fc32
  states: {}
- name: u
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    comment: |-
      Sample rate matches symbol rate to
      avoid interpolation error and no  longer
      requires an arbitrary resampler.
    dev_addr: '"num_recv_frames=128"'
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: sample_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: usrp_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: sample_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,3
    label1: RX Signal
    label2: Filtered
    name: '"RX Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    ymax: '0'
  states: {}

connections:
- [agc, '0', dtv_atsc_sync_0, '0']
- [dc_blocker_xx_0, '0', agc, '0']
- [dtv_atsc_deinterleaver_0, '0', dtv_atsc_rs_decoder_0, '0']
- [dtv_atsc_deinterleaver_0, '1', dtv_atsc_rs_decoder_0, '1']
- [dtv_atsc_depad_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_derandomizer_0, '0', dtv_atsc_depad_0, '0']
- [dtv_atsc_equalizer_0, '0', dtv_atsc_viterbi_decoder_0, '0']
- [dtv_atsc_equalizer_0, '1', dtv_atsc_viterbi_decoder_0, '1']
- [dtv_atsc_fpll_0, '0', dc_blocker_xx_0, '0']
- [dtv_atsc_fs_checker_0, '0', dtv_atsc_equalizer_0, '0']
- [dtv_atsc_fs_checker_0, '1', dtv_atsc_equalizer_0, '1']
- [dtv_atsc_rs_decoder_0, '0', dtv_atsc_derandomizer_0, '0']
- [dtv_atsc_rs_decoder_0, '1', dtv_atsc_derandomizer_0, '1']
- [dtv_atsc_sync_0, '0', dtv_atsc_fs_checker_0, '0']
- [dtv_atsc_viterbi_decoder_0, '0', dtv_atsc_deinterleaver_0, '0']
- [dtv_atsc_viterbi_decoder_0, '1', dtv_atsc_deinterleaver_0, '1']
- [filter_fft_rrc_filter_0, '0', dtv_atsc_fpll_0, '0']
- [filter_fft_rrc_filter_0, '0', usrp_freq_sink, '1']
- [soapy_custom_source_0, '0', filter_fft_rrc_filter_0, '0']
- [soapy_custom_source_0, '0', usrp_freq_sink, '0']
- [u, '0', filter_fft_rrc_filter_0, '0']
- [u, '0', usrp_freq_sink, '0']

metadata:
  file_format: 1
