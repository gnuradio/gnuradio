<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>atsc_sym_rate</value></param>
<param><key>value</key><value>4.5e6/286*684</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampled_rate</value></param>
<param><key>value</key><value>atsc_sym_rate*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>1.1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>displays</value></param>
<param><key>num_tabs</key><value>1</value></param>
<param><key>label0</key><value>RX Spectrum</value></param>
<param><key>gui_hint</key><value>0,0,1,4</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>option0</key><value>TX/RX</value></param>
<param><key>label0</key><value>TX/RX</value></param>
<param><key>option1</key><value>RX2</value></param>
<param><key>label1</key><value>RX2</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>6.25e6</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>18</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>605e6</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>uhd_rx_atsc_short</value></param>
<param><key>title</key><value>Receive ATSC from UHD</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>u</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>sample_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>antenna</value></param>
</block>
<block>
<key>dtv_atsc_rx</key>
<param><key>id</key><value>dtv_atsc_rx_0</value></param>
<param><key>rate</key><value>sample_rate</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>mpeg.ts</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>usrp_freq_sink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"RX Spectrum"</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>gui_hint</key><value>displays@0</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<connection><source_block_id>dtv_atsc_rx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>u</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>dtv_atsc_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>usrp_freq_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
