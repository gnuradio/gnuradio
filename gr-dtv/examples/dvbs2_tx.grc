options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1280e6
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: adv.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/adv16apsk910.ts
    repeat: 'True'
    type: byte
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_16APSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C9_10
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.9, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod-phy
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod-phy
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_1, '0']
- [dtv_dvbs2_physical_cc_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [virtual_source_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [virtual_source_1, '0', dtv_dvbs2_physical_cc_0, '0']

metadata:
  file_format: 1
