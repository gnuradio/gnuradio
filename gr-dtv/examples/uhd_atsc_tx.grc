options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_atsc_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: pilot_freq
  id: variable
  parameters:
    value: (6000000.0 - (symbol_rate / 2)) / 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4500000.0 / 286 * 684
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/advatsc.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '832'
    n: '1024'
    offset: '4'
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: ((-3000000.0 + pilot_freq) / symbol_rate) * (math.pi * 2)
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: dtv_atsc_field_sync_mux_0
  id: dtv_atsc_field_sync_mux
  parameters: {}
  states: {}
- name: dtv_atsc_interleaver_0
  id: dtv_atsc_interleaver
  parameters: {}
  states: {}
- name: dtv_atsc_pad_0
  id: dtv_atsc_pad
  parameters: {}
  states: {}
- name: dtv_atsc_randomizer_0
  id: dtv_atsc_randomizer
  parameters: {}
  states: {}
- name: dtv_atsc_rs_encoder_0
  id: dtv_atsc_rs_encoder
  parameters: {}
  states: {}
- name: dtv_atsc_trellis_encoder_0
  id: dtv_atsc_trellis_encoder
  parameters: {}
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8VSB
    interpolation: INTERPOLATION_OFF
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.11, symbol_rate, symbol_rate/2, 0.1152, 200)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This file is available at
      http://www.w6rz.net/advatsc.ts
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: symbol_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(symbol_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: symbol_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod-rot
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod-rot
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_atsc_pad_0, '0']
- [blocks_keep_m_in_n_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0, '0']
- [dtv_atsc_field_sync_mux_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_atsc_interleaver_0, '0', dtv_atsc_trellis_encoder_0, '0']
- [dtv_atsc_pad_0, '0', dtv_atsc_randomizer_0, '0']
- [dtv_atsc_randomizer_0, '0', dtv_atsc_rs_encoder_0, '0']
- [dtv_atsc_rs_encoder_0, '0', dtv_atsc_interleaver_0, '0']
- [dtv_atsc_trellis_encoder_0, '0', dtv_atsc_field_sync_mux_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_1, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_1, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
