options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbt_rx_demo_8k
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (8000000.0 * 8) / 7
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: advdvbt.ts
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: adv16.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '8192'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '6048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '6048'
    type: byte
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: 16qam
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: 16qam
    gain: '1'
    hierarchy: nh
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_demod_reference_signals_0
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    constellation: 16qam
    guard_interval: GI_1_32
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T8k
    type: complex
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_ofdm_sym_acquisition_0
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    cp_length: '256'
    fft_length: '8192'
    occupied_tones: '6817'
    snr: '30'
    type: complex
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T8k
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: 16qam
    hierarchy: nh
    type: b
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8192'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(8192)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: fft.window.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-170'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"num_recv_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_1, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', blocks_vector_to_stream_0_0, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', dtv_dvbt_demap_0, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_file_sink_0, '0']
- [dtv_dvbt_ofdm_sym_acquisition_0, '0', fft_vxx_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0, '0', dtv_dvbt_demod_reference_signals_0, '0']
- [uhd_usrp_source_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
