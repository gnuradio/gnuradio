options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: catv_tx_256qam
    output_language: python
  states: {}

blocks:
- name: Control_Word
  id: variable
  parameters:
    value: '6'
  states: {}
- name: I_taps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: J_increment
  id: variable
  parameters:
    value: '4'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5360537 * 2
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: vga1_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '-35'
    step: '1'
    stop: '-4'
    value: '-8'
  states: {}
- name: vga2_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/shm/advqam256.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '7'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: I_taps
    type: byte
  states: {}
- name: dtv_catv_frame_sync_enc_bb_0
  id: dtv_catv_frame_sync_enc_bb
  parameters:
    constellation: CATV_MOD_256QAM
    ctrlword: Control_Word
  states: {}
- name: dtv_catv_randomizer_bb_0
  id: dtv_catv_randomizer_bb
  parameters:
    constellation: CATV_MOD_256QAM
  states: {}
- name: dtv_catv_reed_solomon_enc_bb_0
  id: dtv_catv_reed_solomon_enc_bb
  parameters: {}
  states: {}
- name: dtv_catv_transport_framing_enc_bb_0
  id: dtv_catv_transport_framing_enc_bb
  parameters: {}
  states: {}
- name: dtv_catv_trellis_enc_bb_0
  id: dtv_catv_trellis_enc_bb
  parameters:
    constellation: CATV_MOD_256QAM
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_256QAM
    interpolation: INTERPOLATION_ON
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: I_taps
    M: J_increment
    blocks: '1'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.06, samp_rate, samp_rate/2, 0.12, rrc_taps)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, 3500000)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rsenc-convint
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: frame-trellis
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rsenc-convint
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: frame-trellis
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_catv_transport_framing_enc_bb_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', dtv_catv_reed_solomon_enc_bb_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0, '0']
- [dtv_catv_frame_sync_enc_bb_0, '0', virtual_sink_1, '0']
- [dtv_catv_randomizer_bb_0, '0', dtv_catv_frame_sync_enc_bb_0, '0']
- [dtv_catv_reed_solomon_enc_bb_0, '0', blocks_stream_to_vector_0, '0']
- [dtv_catv_transport_framing_enc_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [dtv_catv_trellis_enc_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', fft_filter_xxx_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_catv_randomizer_bb_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [virtual_source_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [virtual_source_1, '0', dtv_catv_trellis_enc_bb_0, '0']

metadata:
  file_format: 1
