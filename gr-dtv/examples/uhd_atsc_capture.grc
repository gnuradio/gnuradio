options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_atsc_capture
    output_language: python
    realtime_scheduling: '1'
    title: Capture ATSC Channel
  states: {}

blocks:
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    comment: Digital Ch 28 - 557MHz
    gui_hint: 0,0,1,2
    label: Center Frequency
    type: real
    value: 557e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '46'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/atsc_11.8385MSPS.iq
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    bandwidth0: '6000000'
    center_freq0: center_freq
    gain0: gain
    samp_rate: sample_rate
    type: fc32
  states: {}
- name: u
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    comment: |-
      Sample rate matches symbol rate to
      avoid interpolation error and no  longer
      requires an arbitrary resampler for decoding.
    dev_addr: '"num_recv_frames=128"'
    dev_args: '""'
    gain0: gain
    rx_agc0: Disabled
    samp_rate: sample_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: usrp_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: sample_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 3,0,1,4
    label1: RX Signal
    name: '"RX Spectrum"'
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-100'
  states: {}

connections:
- [soapy_custom_source_0, '0', blocks_file_sink_0, '0']
- [soapy_custom_source_0, '0', usrp_freq_sink, '0']
- [u, '0', blocks_file_sink_0, '0']
- [u, '0', usrp_freq_sink, '0']

metadata:
  file_format: 1
