options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: file_atsc_rx
    output_language: python
    run_options: run
    title: Receive ATSC from UHD
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: duration
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 605e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '18'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: mpeg.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: atsc_iq.sc16
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: sample_rate
    sps: '1.5'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', dtv_atsc_rx_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
