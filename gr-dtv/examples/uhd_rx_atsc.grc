options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: uhd_rx_atsc
    output_language: python
    title: Receive ATSC from UHD
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Antenna
    label0: TX/RX
    label1: RX2
    num_opts: '2'
    option0: TX/RX
    option1: RX2
    type: string
    value: TX/RX
    widget: radio_buttons
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,1,1,1
    label: Frequency
    type: real
    value: 605e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '31'
    value: '18'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,2,1,1
    label: Sample Rate
    type: real
    value: 6.25e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-5'
    reference: '4.0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: mpeg.ts
    type: byte
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'True'
    type: ff
  states: {}
- name: displays
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,4
    label0: RX Spectrum
    num_tabs: '1'
  states: {}
- name: dtv_atsc_deinterleaver_0
  id: dtv_atsc_deinterleaver
  parameters: {}
  states: {}
- name: dtv_atsc_depad_0
  id: dtv_atsc_depad
  parameters: {}
  states: {}
- name: dtv_atsc_derandomizer_0
  id: dtv_atsc_derandomizer
  parameters: {}
  states: {}
- name: dtv_atsc_equalizer_0
  id: dtv_atsc_equalizer
  parameters: {}
  states: {}
- name: dtv_atsc_fs_checker_0
  id: dtv_atsc_fs_checker
  parameters: {}
  states: {}
- name: dtv_atsc_rs_decoder_0
  id: dtv_atsc_rs_decoder
  parameters: {}
  states: {}
- name: dtv_atsc_sync_0
  id: dtv_atsc_sync
  parameters:
    rate: oversampled_rate
  states: {}
- name: dtv_atsc_viterbi_decoder_0
  id: dtv_atsc_viterbi_decoder
  parameters: {}
  states: {}
- name: fpll
  id: dtv_atsc_fpll
  parameters:
    rate: oversampled_rate
  states: {}
- name: rx_filter
  id: dtv_atsc_rx_filter
  parameters:
    rate: sample_rate
    sps: sps
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"num_recv_frames=128,master_clock_rate=" + str(sample_rate*4)'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sync: none
    type: fc32
  states: {}
- name: usrp_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: sample_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: displays@0
    name: '"RX Spectrum"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: agc-sync
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: viterbi-deint
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: viterbi-deint
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: agc-sync
  states: {}

connections:
- [agc, '0', virtual_sink_0, '0']
- [dc_blocker_xx_0, '0', agc, '0']
- [dtv_atsc_deinterleaver_0, '0', dtv_atsc_rs_decoder_0, '0']
- [dtv_atsc_depad_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_derandomizer_0, '0', dtv_atsc_depad_0, '0']
- [dtv_atsc_equalizer_0, '0', dtv_atsc_viterbi_decoder_0, '0']
- [dtv_atsc_fs_checker_0, '0', dtv_atsc_equalizer_0, '0']
- [dtv_atsc_rs_decoder_0, '0', dtv_atsc_derandomizer_0, '0']
- [dtv_atsc_sync_0, '0', dtv_atsc_fs_checker_0, '0']
- [dtv_atsc_viterbi_decoder_0, '0', virtual_sink_1, '0']
- [fpll, '0', dc_blocker_xx_0, '0']
- [rx_filter, '0', fpll, '0']
- [uhd_usrp_source_0, '0', rx_filter, '0']
- [uhd_usrp_source_0, '0', usrp_freq_sink, '0']
- [virtual_source_0, '0', dtv_atsc_deinterleaver_0, '0']
- [virtual_source_2, '0', dtv_atsc_sync_0, '0']

metadata:
  file_format: 1
