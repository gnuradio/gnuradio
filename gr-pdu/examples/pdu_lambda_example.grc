options:
  parameters:
    author: jacob
    generate_options: qt_gui
    id: pdu_lambda_example
    output_language: python
    title: PDU Lambda Example
  states: {}

blocks:
- name: k
  id: variable_qtgui_range
  parameters:
    label: Vector Scale
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: l
  id: variable_qtgui_range
  parameters:
    label: Metadata Scale
    start: '0'
    step: '.01'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: lambda1
  id: pylambda_message_lambda
  parameters:
    fn: 'lambda msg: pmt.cons(pmt.make_dict(), msg)'
  states: {}
- name: lambda2
  id: pylambda_pdu_lambda
  parameters:
    comment: Scale Metadata
    fn: 'lambda x: x*l'
    key: pmt.intern("distance")
    metadict: Metadata
  states: {}
- name: lambda3
  id: pylambda_pdu_lambda
  parameters:
    comment: Scale uniform vector
    fn: 'lambda x: x*k'
    key: ''
    metadict: Uniform Vector
  states: {}
- name: msg_dbg
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: msg_edit
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    key: pmt.dict
    label: Uniform Vector
    type: int_vec
    value: 1,2,3,4
  states: {}
- name: msg_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '1000'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This flowgraph shows some potential uses for the PDU and
      message lambda blocks. The Message lambda converts a u8vector
      PMT into a PDU, which has a key added. Two PDU lambda blocks
      then operate on the uniform vector part and the metadata part
      respectively.
    note: Flowgraph Summary
  states: {}
- name: pdu_set
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("distance")
    v: pmt.from_double(123)
  states: {}

connections:
- [lambda1, msg, pdu_set, pdus]
- [lambda2, pdu, lambda3, pdu]
- [lambda3, pdu, msg_dbg, print]
- [msg_edit, msg, msg_strobe, set_msg]
- [msg_strobe, strobe, lambda1, msg]
- [pdu_set, pdus, lambda2, pdu]

metadata:
  file_format: 1
