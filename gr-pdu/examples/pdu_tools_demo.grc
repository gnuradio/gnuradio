options:
  parameters:
    author: J. Gilbert
    copyright: 2021 J. Gilbert
    description: Example usage of a range of PDU tools.
    generate_options: qt_gui
    id: pdu_tools_demo
    output_language: python
    title: PDU Tools Example
  states: {}

blocks:
- name: interval
  id: variable
  parameters:
    value: '0.400'
  states: {}
- name: timekey
  id: variable
  parameters:
    value: pmt.intern("SYS_TIME")
  states: {}
- name: val
  id: variable_qtgui_range
  parameters:
    label: KEY1 Metadata Value
    start: '0'
    step: '0.1'
    stop: '500.0'
    value: '123.4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Print out the metadata dictionary.
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Emits pmt.PMT_T
    msg: pmt.PMT_T
    period: int(interval*1000)
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Normally, some PDU processing
      would be done here for the time
      benchmarks to be applied over.
    note: README
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      This flowgraph highlights a number of useful PDU tools together.
      This flowgraph is not intended to do anything particularily useful
      other than serve as a reference / demonstration.
    note: SUMMARY
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    comment: |-
      This block will add the system
      time to the PDU metadata as a
      double precision float. The time
      key can be set by the user.
    key: timekey
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    comment: |-
      This block will add a key/value pair
      to the PDU metadata dictionary.
    k: pmt.intern("KEY1")
    v: pmt.from_double(val)
  states: {}
- name: pdu_pdu_split_0
  id: pdu_pdu_split
  parameters:
    comment: |-
      The PDU will be split into its metadata dictionary
      and uniform vector, which will then be emitted as
      dict/uvec PMT messages respectively.
    pass_empty: 'False'
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    comment: |-
      This block will emit a random PDU with
      an empty dictionary each time it
      receives an input message. The input
      message composition does not matter.
    length_modulo: '256'
    mask: '0xFF'
    maxsize: '4096'
    minsize: '2048'
  states: {}
- name: pdu_time_delta_0
  id: pdu_time_delta
  parameters:
    comment: |-
      This block calculates the ms that have 
      elapsed between when the time key
      was added and now, and print statistics
      when the flowgraph stops.
    delta_key: pmt.intern("time_delta_ms")
    time_key: timekey
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    comment: Colors for fun.
    name: '"This Plot Is Not Meaningful"'
    ncols: '128'
    samp_rate: '1'
    type: msg_byte
    zmax: '127'
    zmin: '-128'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: x
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: y
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: y
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [pdu_add_system_time_0, pdu, pdu_time_delta_0, pdu]
- [pdu_pdu_set_0, pdus, virtual_sink_0, '0']
- [pdu_pdu_split_0, dict, blocks_message_debug_0, print]
- [pdu_pdu_split_0, vec, qtgui_time_raster_sink_x_0, in]
- [pdu_random_pdu_0, pdus, pdu_pdu_set_0, pdus]
- [pdu_time_delta_0, pdu, virtual_sink_1, '0']
- [virtual_source_0, '0', pdu_add_system_time_0, pdu]
- [virtual_source_1, '0', pdu_pdu_split_0, pdu]

metadata:
  file_format: 1
