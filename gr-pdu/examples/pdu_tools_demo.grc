options:
  parameters:
    author: J. Gilbert
    copyright: 2021 J. Gilbert
    description: Example usage of a range of PDU tools.
    generate_options: qt_gui
    id: pdu_tools_demo
    output_language: python
    title: PDU Tools Example
  states: {}

blocks:
- name: interval
  id: variable
  parameters:
    value: '0.400'
  states: {}
- name: timekey
  id: variable
  parameters:
    value: pmt.intern("SYS_TIME")
  states: {}
- name: val
  id: variable_qtgui_range
  parameters:
    label: KEY1 Metadata Value
    orient: QtCore.Qt.Orientation.Horizontal
    start: '0'
    step: '0.1'
    stop: '500.0'
    value: '123.4'
  states: {}
- name: add_sys_time
  id: pdu_add_system_time
  parameters:
    comment: |-
      This block will add the system
      time to the PDU metadata as a
      double precision float. The time
      key can be set by the user.
    key: timekey
  states: {}
- name: msg_dbg
  id: blocks_message_debug
  parameters:
    comment: Print out the metadata dictionary.
  states: {}
- name: msg_strobe
  id: blocks_message_strobe
  parameters:
    comment: Emits pmt.PMT_T
    msg: pmt.PMT_T
    period: int(interval*1000)
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      Normally, some PDU processing
      would be done here for the time
      benchmarks to be applied over.
    note: README
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      This flowgraph highlights a number of useful PDU tools together.
      This flowgraph is not intended to do anything particularly useful
      other than serve as a reference / demonstration.
    note: SUMMARY
  states: {}
- name: pdu_set
  id: pdu_pdu_set
  parameters:
    comment: |-
      This block will add a key/value pair
      to the PDU metadata dictionary.
    k: pmt.intern("KEY1")
    v: pmt.from_double(val)
  states: {}
- name: pdu_split
  id: pdu_pdu_split
  parameters:
    comment: |-
      The PDU will be split into its metadata dictionary
      and uniform vector, which will then be emitted as
      dict/uvec PMT messages respectively.
    pass_empty: 'False'
  states: {}
- name: random_pdu
  id: pdu_random_pdu
  parameters:
    comment: |-
      This block will emit a random PDU with
      an empty dictionary each time it
      receives an input message. The input
      message composition does not matter.
    length_modulo: '256'
    mask: '0xFF'
    maxsize: '4096'
    minsize: '2048'
  states: {}
- name: time_delta
  id: pdu_time_delta
  parameters:
    comment: |-
      This block calculates the ms that have 
      elapsed between when the time key
      was added and now, and print statistics
      when the flowgraph stops.
    delta_key: pmt.intern("time_delta_ms")
    time_key: timekey
  states: {}
- name: time_raster
  id: qtgui_time_raster_sink_x
  parameters:
    comment: Colors for fun.
    name: '"This Plot Is Not Meaningful"'
    ncols: '128'
    samp_rate: '1'
    type: msg_byte
    zmax: '127'
    zmin: '-128'
  states: {}
- name: vs0
  id: virtual_sink
  parameters:
    stream_id: x
  states: {}
- name: vs1
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: vs2
  id: virtual_sink
  parameters:
    stream_id: y
  states: {}
- name: vs3
  id: virtual_source
  parameters:
    stream_id: y
  states: {}

connections:
- [add_sys_time, pdu, time_delta, pdu]
- [msg_strobe, strobe, random_pdu, generate]
- [pdu_set, pdus, vs0, '0']
- [pdu_split, dict, msg_dbg, print]
- [pdu_split, vec, time_raster, in]
- [random_pdu, pdus, pdu_set, pdus]
- [time_delta, pdu, vs2, '0']
- [vs1, '0', add_sys_time, pdu]
- [vs3, '0', pdu_split, pdu]

metadata:
  file_format: 1
