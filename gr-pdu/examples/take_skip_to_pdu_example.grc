options:
  parameters:
    author: jacob
    generate_options: qt_gui
    id: take_skip_to_pdu_example
    output_language: python
    title: Take Skip To PDU Reference
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      This flowgraph shows how the take/skip to PDU block can be used
      to sample a streaming input and ship it off via network for analysis
      or further processing.

      The ZMQ SUB Source and QT Time Sink can be in a separate process
      or on a separate networked system altogether.
    note: README
  states: {}
- name: qt_time
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: sig_src
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate / (123.456)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: take_skip_to_pdu
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '40960'
    take: '1024'
    type: complex
  states: {}
- name: zmq_pub
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:4990
    timeout: '100'
  states: {}
- name: zmq_sub
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:4990
    timeout: '100'
  states: {}

connections:
- [sig_src, '0', take_skip_to_pdu, '0']
- [take_skip_to_pdu, pdus, zmq_pub, in]
- [zmq_sub, out, qt_time, in]

metadata:
  file_format: 1
