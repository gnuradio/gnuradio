options:
  parameters:
    author: J. Gilbert
    copyright: 2021 J. Gilbert
    description: Simple example of generating periodic bursts from PDUs
    generate_options: qt_gui
    id: simple_pdu_to_stream_example
    output_language: python
    title: Simple PDU To Stream Example
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: v
  id: variable
  parameters:
    value: pmt.init_c32vector(N,np.arange(N).tolist())
  states: {}
- name: imp
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: multiply
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/N
    type: complex
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      This is a simple example showing how the PDU to Stream block can
      convert PDU data to streaming data for transmission from a SDR
      such as a USRP including the addition of appropriate stream tags.
    note: Flowgraph Summary
  states: {}
- name: pdu_set
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("tx_time")
    v: pmt.make_tuple(pmt.from_uint64(1),pmt.from_double(0.1234))
  states: {}
- name: pdu_to_stream
  id: pdu_pdu_to_stream_X
  parameters:
    depth: '64'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, v)
    period: '1000'
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    size: N*2
    srate: samp_rate
    type: complex
  states: {}

connections:
- [multiply, '0', time_sink, '0']
- [pdu_set, pdus, pdu_to_stream, pdus]
- [pdu_to_stream, '0', multiply, '0']
- [strobe, strobe, pdu_set, pdus]

metadata:
  file_format: 1
